# Allegro board AI2MAX_AMP_A113X_V10B_210804-001.brd (continued)
## Nets (continued)
5V_EN: C12.2 R1.1 R2.1 R2.2 R3.2 U2.6(EN) UNK5R73.2
GND: C1.2 C2.2 C3.2 C4.2 C6.2 C7.2 C8.2 C9.1 C11.1 C12.1 C13.2 C14.1 C16.2 C17.1 C18.2 C20.1 C21.2 C22.2 C30.2 C51.2 C52.1 C54.2 C55.1 C56.2 C57.2 C58.1 C60.2 C61.1 C62.2 C65.1 C66.1 C67.1 C68.2 C69.1 C71.2 C72.1 C73.2 C75.1 C76.2 C77.2 C78.2 C79.2 C101.1 C102.1 C103.1 C104.1 C105.1 C106.1 C201.2 C203.1 C204.1 C205.2 C206.2 C207.1 C208.1 C209.2 C211.2 C214.2 C216.1 C217.1 C218.2 C219.1 C221.1 C222.1 C223.2 C224.2 C226.1 C228.1 C229.1 C230.2 C231.2 C232.1 C233.2 C235.2 C238.2 C240.1 C241.1 C242.2 C243.1 C245.1 C246.1 C248.2 C249.2 C250.1 C251.1 C252.1 C253.1 C254.1 C255.2 C256.2 C257.2 C258.2 C259.1 C260.2 C261.1 C262.2 C264.2 C265.1 C268.2 C269.1 C301.2 C303.1 C304.1 C305.2 C306.2 C307.1 C308.1 C309.2 C311.2 C314.2 C316.1 C317.1 C318.2 C319.1 C321.1 C322.1 C323.2 C324.2 C326.1 C328.1 C329.1 C330.2 C331.2 C332.1 C333.2 C335.2 C338.2 C340.1 C341.1 C342.2 C343.1 C345.1 C346.1 C348.2 C349.1 C350.1 C351.1 C352.1 C353.2 C354.2 C355.2 C356.2 C357.1 C358.2 C359.1 C360.2 C362.2 C363.1 C366.2 C367.1 J813.3 J813.9 J813.13 J813.15 J813.S1 J813.S2 J813.S3 J813.S4 J813.S5 J814.5(GND#5) J814.6(S1) J814.7(S2) J814.8(S3) J814.9(S4) J814.10(GND#10) J814.11(GND#11) Q2.2(EMITTER) Q3.2(EMITTER) Q4.2(EMITTER) Q5.2(EMITTER) R3.1 R7.1 R9.1 R11.1 R59.1 R60.1 R63.1 R201.2 R204.1 R205.2 R207.1 R220.1 R221.2 R223.1 R233.1 R234.2 R235.1 R236.2 R301.2 R304.1 R305.2 R319.1 R321.2 R339.1 R340.2 R341.1 R342.2 T1.2 T308.1(TP) T311.1(TP) T312.1(TP) T313.1(TP) T314.1(TP) T315.1(TP) T318.1(TP) T320.1(TP) T321.1(TP) U1.A9(DVSS#A9) U1.A14(DVSS#A14) U1.B4(DVSS#B4) U1.B17(DVSS#B17) U1.D5(DVSS#D5) U1.D7(DVSS#D7) U1.D9(DVSS#D9) U1.D12(DVSS#D12) U1.D14(DVSS#D14) U1.E4(DVSS#E4) U1.E5(DVSS#E5) U1.E6(DVSS#E6) U1.E7(DVSS#E7) U1.E8(DVSS#E8) U1.E9(DVSS#E9) U1.E10(DVSS#E10) U1.E11(DVSS#E11) U1.E12(DVSS#E12) U1.E13(DVSS#E13) U1.F3(DVSS#F3) U1.F4(DVSS#F4) U1.F7(DVSS#F7) U1.F8(DVSS#F8) U1.F9(DVSS#F9) U1.F10(DVSS#F10) U1.F11(DVSS#F11) U1.F14(DVSS#F14) U1.G7(DVSS#G7) U1.G8(DVSS#G8) U1.G9(DVSS#G9) U1.G10(DVSS#G10) U1.G11(DVSS#G11) U1.G12(DVSS#G12) U1.G13(DVSS#G13) U1.H1(DVSS#H1) U1.H6(DVSS#H6) U1.H7(DVSS#H7) U1.H8(DVSS#H8) U1.H9(DVSS#H9) U1.H10(DVSS#H10) U1.H11(DVSS#H11) U1.H14(DVSS#H14) U1.H15(DVSS#H15) U1.J7(DVSS#J7) U1.J8(DVSS#J8) U1.J9(DVSS#J9) U1.J10(DVSS#J10) U1.J11(DVSS#J11) U1.J14(DVSS#J14) U1.J17(DVSS#J17) U1.K2(DVSS#K2) U1.K4(DVSS#K4) U1.K5(DVSS#K5) U1.K6(DVSS#K6) U1.K7(DVSS#K7) U1.K8(DVSS#K8) U1.K9(DVSS#K9) U1.K10(DVSS#K10) U1.K12(DVSS#K12) U1.K13(DVSS#K13) U1.L4(DVSS#L4) U1.L5(DVSS#L5) U1.L6(DVSS#L6) U1.L7(DVSS#L7) U1.L8(DVSS#L8) U1.L9(DVSS#L9) U1.L11(DVSS#L11) U1.L12(DVSS#L12) U1.L13(DVSS#L13) U1.L14(DVSS#L14) U1.L15(DVSS#L15) U1.M4(DVSS#M4) U1.M5(DVSS#M5) U1.M9(DVSS#M9) U1.M12(DVSS#M12) U1.M13(DVSS#M13) U1.M14(DVSS#M14) U1.M17(DVSS#M17) U1.N2(DVSS#N2) U1.N3(DVSS#N3) U1.N6(DVSS#N6) U1.N7(DVSS#N7) U1.N9(DVSS#N9) U1.N10(DVSS#N10) U1.N15(DVSS#N15) U1.P2(DVSS#P2) U1.P3(DVSS#P3) U1.P4(DVSS#P4) U1.P5(DVSS#P5) U1.P8(DVSS#P8) U1.P11(DVSS#P11) U1.P14(DVSS#P14) U1.R3(DVSS#R3) U1.R8(DVSS#R8) U1.R17(DVSS#R17) U1.T1(DVSS#T1) U1.T5(DVSS#T5) U1.T9(DVSS#T9) U1.T12(DVSS#T12) U1.T15(DVSS#T15) U1.U3(DVSS#U3) U1.U6(DVSS#U6) U1.U10(DVSS#U10) U1.U13(DVSS#U13) U1.U16(DVSS#U16) U2.4(GND) U3.2(GND) U51.2(GND) U52.2(GND) U53.2(GND) U54.2(GND) U55.2(GND) U201.1(NC1) U201.3(NC2) U201.4(GND) U201.5(NC3) U201.9(NC4) U201.17(PGND2B) U201.22(PGND2A) U201.25(AGND) U201.26(NC5) U201.29(PGND1B) U201.34(PGND1A) U201.39(GND_IO) U201.41(E_PAD) U202.1(NC1) U202.3(NC2) U202.4(GND) U202.5(NC3) U202.9(NC4) U202.17(PGND2B) U202.22(PGND2A) U202.25(AGND) U202.26(NC5) U202.29(PGND1B) U202.34(PGND1A) U202.39(GND_IO) U202.41(E_PAD) U301.1(NC1) U301.3(NC2) U301.4(GND) U301.5(NC3) U301.9(NC4) U301.17(PGND2B) U301.22(PGND2A) U301.25(AGND) U301.26(NC5) U301.29(PGND1B) U301.34(PGND1A) U301.39(GND_IO) U301.41(E_PAD) U302.1(NC1) U302.3(NC2) U302.4(GND) U302.5(NC3) U302.9(NC4) U302.17(PGND2B) U302.22(PGND2A) U302.25(AGND) U302.26(NC5) U302.29(PGND1B) U302.34(PGND1A) U302.39(GND_IO) U302.41(E_PAD) UNK2C1.1 UNK2C2.1 UNK2C3.1 UNK2C4.2 UNK2C5.1 UNK2C6.2 UNK2C7.1 UNK2C8.1 UNK2C9.1 UNK2C10.1 UNK2C11.1 UNK2C12.1 UNK2C13.2 UNK2C14.1 UNK2C15.1 UNK2C16.1 UNK2C17.2 UNK2C19.1 UNK2C20.1 UNK2C22.1 UNK2CON1.1 UNK2D3.2 UNK2D4.2 UNK2Q1.2 UNK2R14.2 UNK2R15.1 UNK2T17.1 UNK2T25.1 UNK2T28.1 UNK2U2.1 UNK2Y2.2 UNK2Y2.4 UNK3C1.1 UNK3C2.1 UNK3C4.1 UNK3C5.1 UNK3C6.2 UNK3C8.2 UNK3C9.1 UNK3C10.1 UNK3C11.1 UNK3C12.1 UNK3C18.1 UNK3C19.1 UNK3C20.1 UNK3C21.1 UNK3C26.2 UNK3C27.1 UNK3C28.2 UNK3C30.1 UNK3C31.1 UNK3C35.1 UNK3C38.1 UNK3C39.1 UNK3C40.1 UNK3C42.1 UNK3C45.1 UNK3C46.1 UNK3C58.1 UNK3C62.1 UNK3R6.1 UNK3R10.1 UNK3R20.1 UNK3U1.A9 UNK3U1.B1 UNK3U1.B3 UNK3U1.B9 UNK3U1.D1 UNK3U1.D8 UNK3U1.E1 UNK3U1.E2 UNK3U1.E8 UNK3U1.F9 UNK3U1.G1 UNK3U1.G8 UNK3U1.G9 UNK3U1.J2 UNK3U1.J8 UNK3U1.M1 UNK3U1.M9 UNK3U1.P1 UNK3U1.P9 UNK3U1.T1 UNK3U1.T9 UNK4C2.1 UNK4C3.1 UNK4C4.1 UNK4C5.2 UNK4C8.1 UNK4C9.1 UNK4C10.1 UNK4C11.1 UNK4C17.1 UNK4C18.1 UNK4C26.1 UNK4C34.1 UNK4C35.1 UNK4C47.2 UNK4C48.1 UNK4C49.1 UNK4K2.1 UNK4K2.2 UNK4R2.1 UNK4R7.1 UNK4R9.2 UNK4R13.1 UNK4R52.1 UNK4U5.2 UNK4U5.13 UNK4U5.23 UNK4U5.25 UNK4U5.27 UNK4U5.33 UNK4U5.36 UNK4U5.40 UNK4U5.46 UNK4U5.48 UNK4U9.AA4 UNK4U9.AA6 UNK4U9.H6 UNK4U9.K4 UNK4U9.M7 UNK4U9.P5 UNK4U9.R10 UNK4U9.T5 UNK4U9.U8 UNK4U9.Y2 UNK4U9.Y5 UNK5C3.1 UNK5C9.1 UNK5C10.1 UNK5C11.1 UNK5C13.1 UNK5D11.2 UNK5D12.2 UNK5R64.2 UNK5R78.2
VCC5V: C6.1 C7.1 C8.1 C9.2 C10.2 C13.1 C14.2 C51.1 C52.2 C57.1 C58.2 C68.1 C69.2 J814.1(VBUS) L1.2 R6.2 R10.2 R17.1 R18.1 R52.2 R329.1 R330.1 R334.1 R337.2 U3.5(IN) U51.5(IN) U52.5(IN) U53.5(IN) UNK5C13.2 UNK5R5.1
VCC_3.3V: C22.1 C79.1 Q1.3(D) U1.A5(VDDIO_Z) U1.K15(AVDD33_USB) U55.1(VIN) U55.3(ON/OFF) UNK2C22.2 UNK2R18.1 UNK2R19.1 UNK2T15.1 UNK4C4.2 UNK4C5.1 UNK4C8.2 UNK4C17.2 UNK4C18.2 UNK4C49.2 UNK4R6.2 UNK4U5.1 UNK4U5.12 UNK4U5.24 UNK4U5.37 UNK4U9.M6 UNK4U9.N5 UNK4U9.T10 UNK4U9.U9 UNK5C10.2
VDD_EE: C60.1 C61.2 C62.1 C64.2 L52.2 R15.2 R53.2 R333.2 U1.F12(VDD_EE#F12) U1.J3(VDD_EE#J3) U1.J4(VDD_EE#J4) U1.J5(VDD_EE#J5) U1.J6(VDD_EE#J6) U1.K11(VDD_EE#K11) UNK1R2.2 UNK2C1.2 UNK2C11.2 UNK2C13.1 UNK2C16.2 UNK2C20.2 UNK2R27.2
VDDAO_3.3V: C16.1 C17.2 C18.1 C19.2 C21.1 C23.2 C101.2 C201.1 C230.1 C249.1 C250.2 C301.1 C330.1 L2.2 Q1.2(S) R8.2 R12.2 R62.1 R105.1 R214.2 R307.1 R314.2 R323.1 R335.1 R336.1 R348.1 R349.1 R350.1 R351.1 T129.1(TP) T316.1(TP) T319.1(TP) U1.D13(VDDIO_AO) U1.K14(VDDIO_A) U201.40(VDD_IO) U202.40(VDD_IO) U301.40(VDD_IO) U302.40(VDD_IO) UNK2C5.2 UNK2C15.2 UNK2CON1.3 UNK2D7.1 UNK2R2.1 UNK2R24.1 UNK2R28.1 UNK2U2.3
VDDCPU: C54.1 C55.2 C56.1 C63.2 L51.2 R51.2 U1.F5(VDDCPU#F5) U1.F6(VDDCPU#F6) U1.G3(VDDCPU#G3) U1.G4(VDDCPU#G4) U1.G5(VDDCPU#G5) U1.G6(VDDCPU#G6) U1.H3(VDDCPU#H3) U1.H4(VDDCPU#H4) U1.H5(VDDCPU#H5) UNK1R1.2 UNK2C2.2 UNK2C4.1 UNK2C6.1 UNK2C7.2 UNK2C8.2 UNK2C14.2 UNK2C19.2
VDDCPU_EN: R54.1 U1.C4(TESTN) UNK2R2.2
VDDCPU_PWM: R56.2 U1.D3(GPIOAO_2//UART_CTS_AO_B//UART_C) UNK1R1.1
VDDEE_PWM: R58.2 U1.D4(GPIOAO_9//I2C_SDA_AO//PWMAO_D) UNK1R2.1
VDDIO_AO18: C76.1 R106.1 U1.H12(AVDD18_SAR_PLL) U1.H13(VDD18_XTAL_IOVREF) U1.J12(AVDD18_DDRPLL) U1.J13(AVDD18_USB) U54.5(VOUT) UNK2C10.2 UNK2C12.2 UNK2C17.1 UNK2R3.2 UNK2R29.2 UNK3C1.2 UNK5C9.2 UNK5R20.1
VDDIO_BOOT: U1.L3(VDDIO_BOOT) UNK4C2.2 UNK4C10.2 UNK4C11.2 UNK4C34.2 UNK4C35.2 UNK4C47.1 UNK4C48.2 UNK4R1.2 UNK4R3.1 UNK4R4.1 UNK4R5.1 UNK4R6.1 UNK4R8.1 UNK4R12.2 UNK4R14.1 UNK4R16.1 UNK4U5.28 UNK4U5.34 UNK4U5.45 UNK4U9.AA3 UNK4U9.AA5 UNK4U9.K6 UNK4U9.W4 UNK4U9.Y4
VDDIO_X: C102.2 R105.2 R106.2 U1.C8(VDDIO_X)
VDDQ1.35V: C71.1 C72.2 C73.1 C74.2 L53.2 R61.2 U1.M6(VDDQ#M6) U1.M7(VDDQ#M7) U1.M8(VDDQ#M8) U1.M10(VDDQ#M10) U1.M11(VDDQ#M11) U1.N4(VDDQ#N4) U1.N5(VDDQ#N5) UNK3C2.2 UNK3C4.2 UNK3C5.2 UNK3C6.1 UNK3C8.1 UNK3C9.2 UNK3C10.2 UNK3C11.2 UNK3C12.2 UNK3C18.2 UNK3C19.2 UNK3C20.2 UNK3C21.2 UNK3C26.1 UNK3C28.1 UNK3C30.2 UNK3C31.2 UNK3C35.2 UNK3C38.2 UNK3C39.2 UNK3C42.2 UNK3C45.2 UNK3C58.2 UNK3C62.2 UNK3R8.2 UNK3R19.2 UNK3U1.A1 UNK3U1.A8 UNK3U1.B2 UNK3U1.C1 UNK3U1.C9 UNK3U1.D2 UNK3U1.D9 UNK3U1.E9 UNK3U1.F1 UNK3U1.G7 UNK3U1.H2 UNK3U1.H9 UNK3U1.K2 UNK3U1.K8 UNK3U1.N1 UNK3U1.N9 UNK3U1.R1 UNK3U1.R9
ACTIVE_STBY: R219.1 R320.1 U1.B11(GPIOX_19//I2C_SDA_C//UART_CTS_E)
AMP_RESET: R215.1 R315.1 T317.1(TP) UNK5R74.2
AMP_SCL: R209.1 U1.A16(GPIOAO_10//I2C_SLAVE_SCK_AO//I2) UNK2R24.2 UNK5R66.2
AMP_SCL_DEV: R209.2 R238.1 R309.1 T306.1(TP)
AMP_SDA: R210.1 U1.B15(GPIOAO_11//I2C_SLAVE_SDA_AO//I2) UNK2R28.2 UNK5R65.2
AMP_SDA_DEV: R210.2 R239.1 R310.1 T305.1(TP)
BCLK: J813.11 UNK5R68.1
CPU_RESET: R240.1 R338.1 U1.A12(RESETN) UNK2R14.1 UNK2U2.2
CTRL_A113X: UNK5R75.2 UNK5R76.1 UNK5R77.1
DATA: J813.12 UNK5R69.1
DDR3_A0: U1.R12(A0) UNK3U1.N3
DDR3_A1: U1.U15(A1) UNK3U1.P7
DDR3_A2: U1.P16(A2) UNK3U1.P3
DDR3_A3: U1.U17(A3) UNK3U1.N2
DDR3_A4: U1.R11(A4) UNK3U1.P8
DDR3_A5: U1.T14(A5) UNK3U1.P2
DDR3_A6: U1.P12(A6) UNK3U1.R8
DDR3_A7: U1.U14(A7) UNK3U1.R2
DDR3_A8: U1.P13(A8) UNK3U1.T8
DDR3_A9: U1.T16(A9) UNK3U1.R3
DDR3_A10: U1.R10(A10) UNK3U1.L7
DDR3_A11: U1.P17(A11) UNK3U1.R7
DDR3_A12: U1.T17(A12) UNK3U1.N7
DDR3_A13: U1.R15(A13) UNK3U1.T3
DDR3_A14: U1.R14(A14(A14/WE_N)) UNK3U1.T7
DDR3_A15: U1.T13(A15(A15/CAS_N)) UNK3U1.M7
DDR3_BA0: U1.N16(BA_0) UNK3U1.M2
DDR3_BA1: U1.U12(BA_1) UNK3U1.N8
DDR3_BA2: U1.M16(BA_2(BG0)) UNK3U1.M3
DDR3_CAS: U1.P15(CAS_N(ACT_N)) UNK3U1.K3
DDR3_CKE0: U1.P10(CKE0) UNK3U1.K9
DDR3_CLKN: U1.T10(CKN) UNK3C7.1 UNK3R2.2 UNK3U1.K7
DDR3_CLKP: U1.U9(CKP) UNK3C7.2 UNK3R2.1 UNK3U1.J7
DDR3_DQ0: U1.T2(DQ0) UNK3U1.A2
DDR3_DQ1: U1.T3(DQ1) UNK3U1.C2
DDR3_DQ2: U1.P6(DQ2) UNK3U1.A7
DDR3_DQ3: U1.U7(DQ3) UNK3U1.D7
DDR3_DQ4: U1.U1(DQ4) UNK3U1.A3
DDR3_DQ5: U1.U2(DQ5) UNK3U1.C3
DDR3_DQ6: U1.R6(DQ6) UNK3U1.B8
DDR3_DQ7: U1.T7(DQ7) UNK3U1.C8
DDR3_DQ8: U1.T8(DQ8) UNK3U1.H7
DDR3_DQ9: U1.R2(DQ9) UNK3U1.F2
DDR3_DQ10: U1.R9(DQ10) UNK3U1.H8
DDR3_DQ11: U1.R4(DQ11) UNK3U1.E3
DDR3_DQ12: U1.R7(DQ12) UNK3U1.F8
DDR3_DQ13: U1.P1(DQ13) UNK3U1.H3
DDR3_DQ14: U1.P9(DQ14) UNK3U1.F7
DDR3_DQ15: U1.R1(DQ15) UNK3U1.G2
DDR3_DQM0: U1.R5(DQM0) UNK3U1.D3
DDR3_DQM1: U1.P7(DQM1) UNK3U1.E7
DDR3_DQSN0: U1.T6(DQSN_0) UNK3U1.B7
DDR3_DQSN1: U1.T4(DQSN_1) UNK3U1.G3
DDR3_DQSP0: U1.U5(DQSP_0) UNK3U1.C7
DDR3_DQSP1: U1.U4(DQSP_1) UNK3U1.F3
DDR3_NCS0: U1.U11(CS0_N) UNK3U1.L2
DDR3_ODT0: U1.R16(ODT0) UNK3U1.K1
DDR3_RAS: U1.T11(RAS_N(A16/RAS_N)) UNK3U1.J3
DDR3_RST: U1.M15(RST_N) UNK3C46.2 UNK3R8.1 UNK3U1.T2
DDR3_WE: U1.R13(WE_N(BG1)) UNK3U1.L3
EMMC_1.8V: C77.1 U55.5(VOUT) UNK4R5.2
GPIOX_16: T125.1(TP) U1.D10(GPIOX_16//I2C_SCK_B//UART_TX_EE)
GPIOX_17: T126.1(TP) U1.D8(GPIOX_17//I2C_SDA_B//UART_RX_EE)
GPIOX_18: T127.1(TP) U1.C10(GPIOX_18//I2C_SCK_C//UART_RTS_E)
GPIOZ_10: U1.E2(GPIOZ_10) UNK2T3.1
HW_VS: U1.D15(SARADC_CH1) UNK2R3.1 UNK2R15.2
I2SIN_BCLK_C: C103.2 R107.2 R227.1 R229.1 R325.1 R327.1 R343.2 T309.1(TP) UNK5R68.2
I2SIN_DATA_C: R103.2 R104.2 UNK5R69.2
I2SIN_LRCK_C: C104.2 R108.2 R228.1 R230.1 R326.1 R328.1 R344.2 T307.1(TP) UNK5R67.2
I2SIN_MCLK_B: R102.2 UNK5R70.2
I2SO_DATA0: C105.2 R109.2 R225.2 R231.2 U201.7(SDATA) U301.7(SDATA)
I2SO_DATA1: C106.2 R110.2 R226.2 R231.1 U202.7(SDATA) U302.7(SDATA)
I2SO_MCLK_A: R101.2 T101.1(TP)
IR_IN: U1.B14(GPIOAO_6//IR_REMOTE_INPUT) UNK2T6.1
IR_OUT: U1.B13(GPIOAO_7//IR_REMOTE_OUT//JTAG_T) UNK2T5.1
LCD_BL_EN: U1.B1(GPIOZ_5//SPI_SS2_A//PWM_A//SPDI) UNK2T21.1
LCD_BL_PWM: U1.C7(GPIOZ_4//SPI_SS1_A//PWM_B//SPDI) UNK2T22.1
LCD_RESET: U1.C2(GPIOZ_6//I2C_SCK_A//UART_CTS_AO) UNK2T24.1
LINE_OUT_DET: U1.D2(GPIOZ_7//I2C_SDA_A//UART_RTS_AO) UNK2T23.1
LINUX_RX: U1.B12(GPIOAO_1//UART_RX_AO_A) UNK2D4.1 UNK2R1.2
LINUX_TX: U1.A13(GPIOAO_0//UART_TX_AO_A) UNK2D3.1 UNK2R16.2
LRCK: J813.10 UNK5R67.1
MCLK: J813.14 UNK5R70.1
MDDR3_VREF1: UNK3C27.2 UNK3C40.2 UNK3R19.1 UNK3R20.2 UNK3U1.H1 UNK3U1.M8
NAND_ALE: U1.M1(BOOT_9//EMMC_RST//NAND_ALE//NOR) UNK4U5.17 UNK4U9.U5
NAND_CLE: U1.L2(BOOT_10//EMMC_CMD//NAND_CLE) UNK4R14.2 UNK4U5.16 UNK4U9.W5
NAND_CS1: U1.L1(BOOT_8//EMMC_CLK//NAND_CE0) UNK4C3.2 UNK4R1.1 UNK4R11.1 UNK4R11.2 UNK4U5.9 UNK4U9.W6
NAND_D0: U1.F2(BOOT_0//EMMC_D0) UNK4R16.2 UNK4R19.1 UNK4R19.2 UNK4U5.29 UNK4U9.H3
NAND_D1: U1.F1(BOOT_1//EMMC_D1) UNK4R20.1 UNK4R20.2 UNK4U5.30 UNK4U9.H4
NAND_D2: U1.G1(BOOT_2//EMMC_D2) UNK4R21.1 UNK4R21.2 UNK4U5.31 UNK4U9.H5
NAND_D3: U1.G2(BOOT_3//EMMC_D3//NOR_HOLDN) UNK4R22.1 UNK4R22.2 UNK4U5.32 UNK4U9.J2
NAND_D4: U1.H2(BOOT_4//EMMC_D4//NOR_D//POC0) UNK4R23.1 UNK4R23.2 UNK4R52.2 UNK4U5.41 UNK4U9.J3
NAND_D5: U1.J1(BOOT_5//EMMC_D5//NOR_Q//POC1) UNK4R10.2 UNK4R24.1 UNK4R24.2 UNK4U5.42 UNK4U9.J4
NAND_D6: U1.J2(BOOT_6//EMMC_D6//NOR_C//POC2) UNK4R13.2 UNK4R25.1 UNK4R25.2 UNK4U5.43 UNK4U9.J5
NAND_D7: U1.K1(BOOT_7//EMMC_D7//POC3) UNK4R2.2 UNK4R26.1 UNK4R26.2 UNK4U5.44 UNK4U9.J6
NAND_NR/B: U1.K3(BOOT_13//EMMC_DS//NAND_RB) UNK4R9.1 UNK4R12.1 UNK4R17.1 UNK4U5.6 UNK4U5.7
NAND_NRE: U1.M2(BOOT_12//NAND_REN_WR) UNK4R18.1 UNK4R18.2 UNK4U5.8
NAND_NWE: U1.N1(BOOT_11//NAND_WEN_CLK) UNK4R15.1 UNK4R15.2 UNK4U5.18
NAND_PSL: UNK4R3.2 UNK4U5.39
NAND_VSP: UNK4R7.2 UNK4R8.2 UNK4U5.38
NPWM_OFF1: R219.2 U201.12(\\F\A\U\L\T) U202.12(\\F\A\U\L\T)
NPWM_OFF2: R320.2 U301.12(\\F\A\U\L\T) U302.12(\\F\A\U\L\T)
NRESET_AMP: R216.1 R316.1 U1.B6(GPIOX_20//PWM_A)
NRST_AMP1: C204.2 C226.2 R215.2 R216.2 R240.2 U201.36(\\R\E\S\E\T) U202.36(\\R\E\S\E\T)
NRST_AMP2: C304.2 C326.2 R315.2 R316.2 R338.2 U301.36(\\R\E\S\E\T) U302.36(\\R\E\S\E\T)
OUT1A_B_LF: C233.1 C237.1 C261.2 C267.1 FB203.1 L203.2 L213.2 R220.2
OUT1A_B_LW: C209.1 C213.1 C259.2 C263.1 FB202.2 L201.2 L211.2 R204.2
OUT1A_B_RF: C333.1 C337.1 C359.2 C365.1 FB303.1 L303.2 L313.2 R319.2
OUT1A_B_RW: C309.1 C313.1 C357.2 C361.1 FB302.2 L301.2 L311.2 R304.2
OUT2A_B_LF: C237.2 C240.2 C262.1 C270.2 FB204.1 L204.2 L214.2 R221.1
OUT2A_B_LW: C213.2 C216.2 C260.1 C266.2 FB201.2 L202.2 L212.2 R205.1
OUT2A_B_RF: C337.2 C340.2 C360.1 C368.2 FB304.1 L304.2 L314.2 R321.1
OUT2A_B_RW: C313.2 C316.2 C358.1 C364.2 FB301.2 L302.2 L312.2 R305.1
PDM_DCLK: T102.1(TP) U1.E16(GPIOA_14//PDM_DCLK//CLKSYN_IN//)
PDM_DIN0: T103.1(TP) U1.E17(GPIOA_15//PDM_DIN0//PWM_B)
PDM_DIN1: T104.1(TP) U1.D16(GPIOA_16//PDM_DIN1//PWM_C)
PDM_DIN2: T105.1(TP) U1.D17(GPIOA_17//PDM_DIN2//I2C_SDA_C//)
PDM_DIN3: T106.1(TP) U1.C17(GPIOA_18//PDM_DIN3//I2C_SCK_C//)
POWERSTB: R12.1 R13.1 U1.C12(GPIOAO_12//CLK12_24//PWMAO_B)
PVREF: U1.N11(PVREF) UNK3T1.1
PWR_24V: C1.1 C2.1 C3.1 C4.1 C30.1 C205.1 C206.1 C223.1 C224.1 C231.1 C248.1 C255.1 C256.1 C257.1 C258.1 C305.1 C306.1 C323.1 C324.1 C331.1 C348.1 C353.1 C354.1 C355.1 C356.1 R1.2 T1.1 U2.2(VIN) U201.19(PVDD2B) U201.20(PVDD2A) U201.31(PVDD1B) U201.32(PVDD1A) U202.19(PVDD2B) U202.20(PVDD2A) U202.31(PVDD1B) U202.32(PVDD1A) U301.19(PVDD2B) U301.20(PVDD2A) U301.31(PVDD1B) U301.32(PVDD1A) U302.19(PVDD2B) U302.20(PVDD2A) U302.31(PVDD1B) U302.32(PVDD1A)
RMII_MDC: T322.1(TP) U1.A11(GPIOX_22//ETH_MDC)
RMII_MDIO: T323.1(TP) U1.A8(GPIOX_21//ETH_MDIO)
RMII_RXCLK: T325.1(TP) U1.B7(GPIOX_12//TDMA_SCLK//TDMA_SLV_S)
RMII_RXD0: T327.1(TP) U1.B8(GPIOX_13//TDMA_FS//TDMA_SLV_FS/)
RMII_RXD1: T326.1(TP) U1.A6(GPIOX_14//TDMA_DIN0//TDMA_DOUT0)
RMII_RXDV: T324.1(TP) U1.A7(GPIOX_15//TDMA_DOUT0//TDMA_DOUT)
RMII_TXD0: T328.1(TP) U1.A10(GPIOX_8//UART_TX_EE_A//RMII_TXD)
RMII_TXD1: T331.1(TP) U1.C9(GPIOX_9//UART_RX_EE_A//RMII_TXD)
RMII_TXEN: T329.1(TP) U1.B9(GPIOX_10//UART_CTS_EE_A//PWM_C/)
SCL: J813.8 UNK5R66.1
SCL_AMP1: C222.2 C246.2 R211.2 R238.2 R349.2 U201.11(SCL) U202.11(SCL)
SCL_AMP2: C322.2 C346.2 R309.2 R311.2 R351.2 U301.11(SCL) U302.11(SCL)
SDA: J813.7 UNK5R65.1
SDA_AMP1: C217.2 C241.2 R212.2 R239.2 R348.2 U201.10(SDA) U202.10(SDA)
SDA_AMP2: C317.2 C341.2 R310.2 R312.2 R350.2 U301.10(SDA) U302.10(SDA)
SPDIF_IN: T107.1(TP) U1.E14(GPIOA_19//SPDIF_IN//SPDIF_OUT//)
SPDIF_OUT: T108.1(TP) U1.C16(GPIOA_20//SPDIF_OUT//SPDIF_IN//)
SPI_CLK: U1.C6(GPIOZ_0//SPI_CLK_A//UART_RTS_EE) UNK2T16.1
SPI_MISO: U1.D6(GPIOZ_2//SPI_MISO_A//UART_TX_EE) UNK2T19.1
SPI_MOSI: U1.C5(GPIOZ_1//SPI_MOSI_A//UART_CTS_E) UNK2T18.1
SPI_SS0: U1.C1(GPIOZ_3//SPI_SS0_A//UART_RX_EE_) UNK2T20.1
SPK_I2C_SCK: R211.1 R311.1 U1.E3(GPIOZ_8//I2C_SCK_B//UART_TX_AO_) UNK2R18.2 UNK2T26.1
SPK_I2C_SDA: R212.1 R312.1 U1.D1(GPIOZ_9//I2C_SDA_B//UART_RX_AO_) UNK2R19.2 UNK2T27.1
SPK_RST: U1.C15(GPIOAO_4//UART_TX_AO_B//I2C_SCK) UNK2T8.1
STANDBY_A113X: U1.C13(GPIOAO_8//CLK_32K_IN//I2C_SCK_A) UNK5R77.2
SYS_LED: U1.A15(GPIOAO_3//UART_RTS_AO_B//UART_R) UNK2R8.2
USB_PWR_EN: U1.C11(GPIOAO_5//UART_RX_AO_B//I2C_SDA) UNK2T7.1
USB_TXRTUNE: U1.J15(USB_TXRTUNE) UNK5R64.1
USBOTG_A_DM: U1.L16(USB_DM) UNK5D12.1 UNK5R71.2 UNK5R84.2
USBOTG_A_DP: U1.L17(USB_DP) UNK5D11.1 UNK5R72.2 UNK5R85.2
USBOTG_A_ID: U1.K17(USB_ID) UNK5C3.2 UNK5R20.2 UNK5R76.2 UNK5R78.1 UNK5R83.2
USBOTG_A_VBUS: U1.K16(USB_VBUS) UNK5C11.2 UNK5R5.2
WPN: UNK4C9.2 UNK4R4.2 UNK4U5.19
N21450221: C23.1 Q1.1(G) R13.2
N21455517: U1.F13(VDDAO_0V9) UNK2R27.1
N21455804: U1.E15(SARADC_CH0) UNK2R29.1
N21455846: UNK2Q1.3 UNK2R12.2
N21455854: UNK2D7.2 UNK2R12.1
N21456017: U1.D11(GPIOAO_13//CLK25_EE//GEN_CLK_AO) UNK2T29.1
N21456060: U1.B16(SYS_OSCIN) UNK2C3.2 UNK2R5.1 UNK2Y2.1
N21456068: U1.A17(SYS_OSCOUT) UNK2R10.2
N21456125: UNK2C9.2 UNK2R5.2 UNK2R10.1 UNK2Y2.3
N21456352: UNK2CON1.4 UNK2R1.1
N21456391: UNK2CON1.2 UNK2R16.1
N21464427: U1.N8(PZQ) UNK3R6.2
N21467829: U1.M3(BOOT_14//NOR_CS) UNK4T25.1
N21468142: UNK4K2.3 UNK4K2.4 UNK4R10.1
N21476089: R101.1 U1.J16(GPIOA_0//MCLK_C//CLKSYN_IN//PWM)
N21476146: R102.1 U1.H17(GPIOA_1//MCLK_B//SPDIF_IN//SPDI)
N21492258: C53.2 L51.1 U51.6(LX)
N21492341: C65.2 R54.2 R337.1 U51.4(EN)
N21492347: C53.1 U51.1(BS)
N21492451: C63.1 R51.1 R55.1 R59.2 U51.3(FB)
N21492734: C66.2 R55.2 R56.1
N21494202: C78.1 R334.2 R335.2 U54.1(VIN)
N21494218: R331.1 R336.2 U54.3(ON/OFF)
N21499562: C59.2 L52.1 U52.6(LX)
N21499612: R52.1 U52.4(EN)
N21499616: C59.1 U52.1(BS)
N21499652: C64.1 R53.1 R57.1 R60.2 U52.3(FB)
N21499757: C67.2 R57.2 R58.1
N21500929: C70.2 L53.1 U53.6(LX)
N21500979: C75.2 R62.2 U53.4(EN)
N21500983: C70.1 U53.1(BS)
N21501019: C74.1 R61.1 R63.2 U53.3(FB)
N21504673: C5.1 U2.5(BST)
N21504675: C5.2 L1.1 U2.3(SW)
N21504709: R20.1 U2.8(FB)
N21504737: C10.1 R10.1 R11.2 R20.2
N21506095: C15.2 L2.1 U3.6(LX)
N21506141: C20.2 R6.1 R7.2 R19.1 U3.4(EN)
N21506145: C15.1 U3.1(BS)
N21506181: C19.1 R8.1 R9.2 U3.3(FB)
N21534101: UNK3R10.2 UNK3U1.L8
N21597998: UNK2Q1.1 UNK2R8.1
N21714583: C202.2 C210.1 L201.1 L211.1 R202.2 R203.1 U201.30(OUT1B) U201.33(OUT1A)
N21714609: C251.2 R227.2 U201.38(BCK)
N21714673: C203.2 R202.1
N21714680: C202.1 U201.35(BST1A)
N21714717: R201.1 U201.37(AD)
N21714779: C207.2 R203.2
N21714803: C208.2 U201.2(VDD_PLL)
N21714950: C210.2 U201.28(BST1B)
N21714966: C211.1 U201.27(VDR1)
N21715014: C218.1 U201.6(DVDD)
N21715038: C214.1 U201.24(VDR2)
N21715056: C215.2 U201.23(BST2A)
N21715058: C215.1 C220.1 L202.1 L212.1 R206.2 R208.1 U201.18(OUT2B) U201.21(OUT2A)
N21715192: C219.2 R206.1
N21715198: T201.1(TP) U201.13(MONITOR_0)
N21715200: R207.2 U201.14(MONITOR_1)
N21715202: T202.1(TP) U201.15(MONITOR_2)
N21715204: C220.2 U201.16(BST2B)
N21715315: C221.2 R208.2
N21715401: FB202.1 J803.1
N21715403: FB201.1 J803.2
N21715405: FB203.2 J803.4
N21715413: FB204.2 J803.3
N21715441: C225.2 C234.1 L203.1 L213.1 R213.2 R217.1 U202.30(OUT1B) U202.33(OUT1A)
N21715461: C253.2 R229.2 U202.38(BCK)
N21715523: C228.2 R213.1
N21715527: C225.1 U202.35(BST1A)
N21715561: R214.1 U202.37(AD)
N21715623: C229.2 R217.2
N21715647: C232.2 U202.2(VDD_PLL)
N21715792: C234.2 U202.28(BST1B)
N21715808: C235.1 U202.27(VDR1)
N21715856: C242.1 U202.6(DVDD)
N21715880: C238.1 U202.24(VDR2)
N21715898: C239.2 U202.23(BST2A)
N21715900: C239.1 C244.1 L204.1 L214.1 R222.2 R224.1 U202.18(OUT2B) U202.21(OUT2A)
N21716032: C243.2 R222.1
N21716038: T203.1(TP) U202.13(MONITOR_0)
N21716040: R223.2 U202.14(MONITOR_1)
N21716042: T204.1(TP) U202.15(MONITOR_2)
N21716044: C244.2 U202.16(BST2B)
N21716155: C245.2 R224.2
N21722582: C302.2 C310.1 L301.1 L311.1 R302.2 R303.1 U301.30(OUT1B) U301.33(OUT1A)
N21722605: C349.2 R325.2 U301.38(BCK)
N21722669: C303.2 R302.1
N21722673: C302.1 U301.35(BST1A)
N21722707: R301.1 U301.37(AD)
N21722769: C307.2 R303.2
N21722793: C308.2 U301.2(VDD_PLL)
N21722936: C310.2 U301.28(BST1B)
N21722954: C311.1 U301.27(VDR1)
N21722998: C318.1 U301.6(DVDD)
N21723019: C314.1 U301.24(VDR2)
N21723038: C315.2 U301.23(BST2A)
N21723040: C315.1 C320.1 L302.1 L312.1 R306.2 R308.1 U301.18(OUT2B) U301.21(OUT2A)
N21723161: C319.2 R306.1
N21723167: T301.1(TP) U301.13(MONITOR_0)
N21723169: R307.2 U301.14(MONITOR_1)
N21723171: T302.1(TP) U301.15(MONITOR_2)
N21723173: C320.2 U301.16(BST2B)
N21723285: C321.2 R308.2
N21723435: FB302.1 J804.1
N21723437: FB301.1 J804.2
N21723451: FB303.2 J804.4
N21723475: FB304.2 J804.3
N21723494: C325.2 C334.1 L303.1 L313.1 R313.2 R317.1 U302.30(OUT1B) U302.33(OUT1A)
N21723515: C351.2 R327.2 U302.38(BCK)
N21723601: C328.2 R313.1
N21723605: C325.1 U302.35(BST1A)
N21723639: R314.1 U302.37(AD)
N21723713: C329.2 R317.2
N21723762: C332.2 U302.2(VDD_PLL)
N21723903: C334.2 U302.28(BST1B)
N21723921: C335.1 U302.27(VDR1)
N21723965: C342.1 U302.6(DVDD)
N21723986: C338.1 U302.24(VDR2)
N21724005: C339.2 U302.23(BST2A)
N21724007: C339.1 C344.1 L304.1 L314.1 R322.2 R324.1 U302.18(OUT2B) U302.21(OUT2A)
N21724126: C343.2 R322.1
N21724132: T303.1(TP) U302.13(MONITOR_0)
N21724134: R323.2 U302.14(MONITOR_1)
N21724136: T304.1(TP) U302.15(MONITOR_2)
N21724138: C344.2 U302.16(BST2B)
N21724244: C345.2 R324.2
N21727322: J812.2 T1.4
N21727332: J812.1 T1.3
N21729503: C11.2 U2.7(SS)
N21735247: UNK4C26.2 UNK4U9.K2
N21735401: UNK4R17.2 UNK4U9.R5
N21775203: J813.1 UNK5R71.1
N21775223: J813.2 UNK5R72.1
N21775243: J813.4 UNK5R73.1
N21775263: J813.5 UNK5R74.1
N21775283: J813.6 UNK5R75.1
N21778072: T109.1(TP) U1.A4(GPIOX_0//SDIO_D0//JTAG_TDO)
N21778081: T110.1(TP) U1.B5(GPIOX_1//SDIO_D1//JTAG_TDI)
N21778090: T111.1(TP) U1.B2(GPIOX_2//SDIO_D2//UART_RX_AO_A)
N21778099: T112.1(TP) U1.A2(GPIOX_3//SDIO_D3//UART_TX_AO_A)
N21778148: T113.1(TP) U1.A3(GPIOX_4//SDIO_CLK//JTAG_CLK)
N21778157: T114.1(TP) U1.B3(GPIOX_5//SDIO_CMD//JTAG_TMS)
N21778166: T115.1(TP) U1.A1(GPIOX_6)
N21778175: T116.1(TP) U1.C3(GPIOX_7)
N21778255: T120.1(TP) U1.B10(GPIOX_11//UART_RTS_EE_A//PWM_D)
N21800110: R225.1 R226.1 T310.1(TP)
N21860313: C252.2 R228.2 U201.8(WCK)
N21864534: C254.2 R230.2 U202.8(WCK)
N21877006: C350.2 R326.2 U301.8(WCK)
N21880362: C352.2 R328.2 U302.8(WCK)
N21888872: Q3.3(COLLECTOR) R16.2 R17.2
N21888995: Q2.3(COLLECTOR) R18.2 R19.2
N21888998: Q2.1(BASE) R16.1
N21889394: Q3.1(BASE) R15.1
N21890397: Q4.3(COLLECTOR) R329.2 R332.2
N21890399: Q5.3(COLLECTOR) R330.2 R331.2
N21890429: Q5.1(BASE) R332.1
N21890459: Q4.1(BASE) R333.1
N21892579: R343.1 U1.G15(GPIOA_8//TDMB_SCLK//TDMB_SLV_SC)
N21892587: R344.1 U1.F17(GPIOA_9//TDMB_FS//TDMB_SLV_FS)
N21892603: R103.1 U1.F16(GPIOA_10//TDMB_DOUT0//TDMB_DIN0)
N21892620: R104.1 U1.F15(GPIOA_11//TDMB_DOUT1//TDMB_DIN1)
N21892674: R107.1 U1.H16(GPIOA_2//TDMC_SCLK//TDMC_SLV_SC)
N21892682: R108.1 U1.G17(GPIOA_3//TDMC_FS//TDMC_SLV_FS//)
N21892690: R109.1 U1.G16(GPIOA_4//TDMC_DOUT0//TDMC_DIN0/)
N21892698: R110.1 U1.G14(GPIOA_5//TDMC_DOUT1//TDMC_DIN1/)
N22017810: J814.2(D-) UNK5R84.1
N22017884: J814.4(ID) UNK5R83.1
N22060831: J814.3(D+) UNK5R85.1
N22093750: C263.2 C264.1 R233.2
N22093974: C265.2 C266.1 R234.1
N22094186: C267.2 C268.1 R235.2
N22094236: C269.2 C270.1 R236.1
N22099090: C361.2 C362.1 R339.2
N22099146: C363.2 C364.1 R340.1
N22099525: C365.2 C366.1 R341.2
N22099581: C367.2 C368.1 R342.1

Pads without a net: NOREF#3 1; NOREF#4 1; NOREF#13 1; NOREF#23 1; NOREF#30 1; NOREF#31 1; NOREF#32 1; NOREF#38 1; NOREF#46 1; NOREF#49 1; NOREF#50 1; NOREF#51 1; NOREF#52 1; NOREF#53 1; T330 1; U1 N12 N13 N14; U2 1; U54 4; U55 4; UNK3U1 J1 J9 L1 L9; UNK4U5 3 4 5 10 11 14 15 20 21 22 26 35 47; UNK4U9 A4 A6 A9 A11 AA1 AA2 AA7 AA8 AA9 AA10 AA11 AA12 AA13 AA14 AE1 AE14 AG2 AG13 AH4 AH6 AH9 AH11 B2 B13 D1 D14 H1 H2 H7 H8 H9 H10 H11 H12 H13 H14 J1 J7 J8 J9 J10 J11 J12 J13 J14 K1 K3 K5 K7 K8 K9 K10 K11 K12 K13 K14 L1 L2 L3 L4 L12 L13 L14 M1 M2 M3 M5 M8 M9 M10 M12 M13 M14 N1 N2 N3 N10 N12 N13 N14 P1 P2 P3 P10 P12 P13 P14 R1 R2 R3 R12 R13 R14 T1 T2 T3 T12 T13 T14 U1 U2 U3 U6 U7 U10 U12 U13 U14 V1 V2 V3 V12 V13 V14 W1 W2 W3 W7 W8 W9 W10 W11 W12 W13 W14 Y1 Y3 Y6 Y7 Y8 Y9 Y10 Y11 Y12 Y13 Y14

## Via types
v1: diameter 0.4, hole 0.2, TOP to BOTTOM, 429 vias
v2: diameter 0.45, hole 0.25, TOP to BOTTOM, 1270 vias
v3: diameter 0.508, hole 0.254, TOP to BOTTOM, 9 vias
v4: diameter 0.66, hole 0.406, TOP to BOTTOM, 2 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
5V_EN: length 104.2
  TOP w0.1: v2(66.4,16.5) 66.25,16.5 65.8,16.95 65.8,17.52 60.15,23.17 60.15,23.55 59.9,23.8 59.1,23.8 v2(58.7,24.2) ; v2(20.7,4.15) v2(20.7,19) ; v2(89.6,12.7) 88.6,12.7 88.1,13.2 88.1,14.45 86.05,16.5 78.95,16.5 78.35,15.9 77.74,15.9 v2(77.34,15.5)
  TOP w0.25: v2(26.8,4.2) 26.85,4.15 U2.6
  BOTTOM w0.1: v2(66.4,16.5) 66.8,16.1 76.54,16.1 77.14,15.5 v2(77.34,15.5) ; UNK5R73.2 v2(89.6,12.7) ; R1.1 v2(26.8,4.2) R2.1 ; v2(58.7,24.2) 58.6,24.2 57.4,25.4 48.65,25.4 47.3,24.05 45.15,24.05 44,25.2 42.45,25.2 41.75,24.5 39.4,24.5 36.75,21.85 36.15,21.85 33.5,19.2 20.9,19.2 v2(20.7,19) ; R3.2 R2.1 ; R2.1 R2.2 25.2,4.15 C12.2 v2(20.7,4.15)
GND: length 2661.3
  TOP w0.1: v1(71.12,42.64) 71.77,42.64 ; 71.77,42.64 71.77,43.3 ; 71.77,42.64 v1(72.42,42.64) ; 100,26.55 v2(99.95,26.5) ; 58.4,52.75 59.75,52.75 ; v1(73.72,41.99) v1(73.72,42.64) ; 68.53,41.34 68.51,41.32 68.51,41
  TOP w0.102: U1.P8 U1.R8 ; v1(71.12,36.96) 70.99,37.09 70.12,37.09 69.66,37.56 69.66,38.06 ; v1(61.87,49.79) 62.16,49.79 63.89,48.06 64.59,48.06 64.79,47.86 65.25,47.86 U1.F3 ; U1.H1 64.5,46.22 64.82,46.54 65.27,46.54 ; 62.48,33.96 63.91,33.96 64.14,33.73 64.14,32.34 ; v1(83.08,46.87) 81.42,46.87 80.78,46.23 75.79,46.23 75.47,46.55 v1(73.72,46.55) ; UNK3U1.J2 64.96,29.14 65.93,29.14 ; 72.4,49.81 72.4,50.31 72.74,50.65 U1.A14 ; 65.91,50.45 v1(65.91,50.45) 65.91,50.45 ; 65.91,50.45 65.91,51.67 v1(65.96,51.72) ; 64.16,23.52 64.16,24.32 UNK3U1.P1 63.9,24.73 64.29,25.12 64.71,25.12 64.94,25.35 v1(64.94,25.94) 65.86,25.94 v1(66.04,26.11) ; v1(72.42,44.59) 72.42,44.58 72.41,44.59 72.41,44.59 ; v1(72.42,44.59) 72.41,44.59 ; v1(72.42,44.59) 72.41,44.6 72.41,44.59 ; v1(72.74,38.36) 72.39,38.71 72.21,38.71 71.42,39.5 71.42,39.73 71.12,40.03 71.12,40.7 ; v1(68.19,34.74) 68.02,34.91 68.02,36.64 67.69,36.97 v1(67.69,37.19) ; v1(70.2,39.88) 70.47,39.57 70.47,39.29 70.75,39 71.27,39 71.97,38.3 71.97,38.09 v1(71.98,38.08) ; 64.24,34.06 64.13,33.96 v1(64.13,33.94) ; U1.K2 64.62,44.6 64.14,44.6 63.91,44.38 v1(62.58,44.38) ; 71.42,43.64 71.12,43.33 v1(71.12,42.64) ; v1(63.24,41.53) 63.7,41.99 64.61,41.99 U1.P2 ; v1(73.07,40.69) 73.07,40.7 ; v1(66.56,49.15) v1(66.56,49.8) ; v1(64.23,28.4) 64.18,28.35 63.24,28.35 63.17,28.27 63.17,28.25 ; 67.51,31.55 v1(68.96,31.55) ; v1(65.3,37.06) 65.3,36.79 66.24,35.85 66.24,32.29 65.85,31.89 v1(65.85,31.65) 65.72,31.52 64.96,31.52 UNK3U1.E2 ; U1.T1 64.42,41.02 64.74,41.35 v1(65.26,41.35) 65.26,40.88 65.07,40.69 64.79,40.69 64.61,40.52 64.61,40.09 v1(64.4,39.88) ; v1(68.6,41.41) 68.53,41.34 68.08,41.34 67.86,41.12 67.86,40.89 67.54,40.57 U1.U6 ; U1.H15 73.71,45.9 74.14,45.9 74.47,45.57 U1.J17 ; U1.M17 74.51,43.62 74.19,43.94 v1(73.72,43.94) ; 74.09,27.51 74.09,27.08 73.35,26.34 v1(72.92,26.34) ; 72.42,43.29 72.42,43.08 72.42,43.08 v1(72.42,42.64) ; U1.T9 69.51,41 69.51,40.87 69.19,40.54 69.19,39.49 69.57,39.11 69.57,38.34 v1(69.74,38.17) 69.66,38.06 ; 69.16,42.64 69.14,42.64 ; 68.51,41 68.51,40.64 68.55,40.6 68.55,38.97 v1(68.7,38.81) ; v1(66.51,29.24) 66.61,29.14 v1(68.95,29.14) ; v1(65.91,45.24) v1(65.26,45.24) 65.26,45.49 65.27,45.49 65.27,46.54 ; v1(72.51,39.65) 72.5,39.66 ; 63.17,28.25 63.17,28.22 ; 63.17,28.25 v1(63.09,28.15) ; 69.66,38.06 69.74,38.15 ; 66.57,40.7 66.57,38.93 66.49,38.85 ; v1(66.49,37.19) 66.49,36.88 67.13,36.25 67.13,30.88 67.11,30.86 67.11,30.79 ; 65.27,46.54 65.27,47.2 ; v1(69.78,30.7) 69.78,30.77 ; v1(72.49,28.58) 72.11,28.2 71.41,28.2 71.37,28.34 ; 74.09,28.22 73.12,27.26 v1(72.16,27.26) ; 73.08,42.65 73.07,42.64 73.08,42.65
  TOP w0.127: v1(72,30.09) 71.91,30.01 71.45,29.55 71.45,29.63 v1(71.37,29.56)
  TOP w0.14: 67.51,32.34 68.96,32.34 v1(68.95,32.34)
  TOP w0.15: v1(64.61,42.64) 64.61,42.65 63.31,42.65 v1(63.19,42.52)
  TOP w0.152: v1(71.37,29.56) 71.37,28.34 69.75,28.34 ; v1(64.97,33.96) 64.96,33.94 64.36,33.94 63.97,34.34 63.75,34.34
  TOP w0.2: 68.9,62.95 65.75,62.95 UNK2Q1.2 ; 68.9,62.95 v2(68.9,62.45) ; 68.9,62.95 70.95,62.95 71,63 72.6,63 v1(73.65,61.95) UNK2C15.1 ; 42.4,25.2 42.45,25.15 42.45,14.5 v2(42.95,14) ; 44.5,4.25 49.35,4.25 C67.1 ; 44.5,4.25 43.2,5.55 43.2,12.75 41.9,14.05 41.9,23.3 v2(41.35,23.85) ; 44.5,4.25 44.35,4.1 42.85,4.1 42.6,4.35 42.6,12.55 41.35,13.8 41.35,22.8 40.65,23.5 40.65,53.3 40.15,53.8 v2(40.15,54) ; 44.3,10.8 44.3,6.7 v2(44.65,6.35) v2(45.7,6.35) 45.7,5.8 45.4,5.5 44.8,5.5 v2(44.5,5.2) 43.7,6 43.7,13.15 43.05,13.8 ; 44.3,10.8 v2(44.3,14) ; 44.3,10.8 U52.2 ; UNK4U9.Y5 UNK4U9.AA6 ; v1(75.74,22.76) 75.74,22.76 75.55,22.95 ; 89.6,57.4 89.55,57.45 89.55,58.8 89.6,58.85 ; v1(78.86,44.63) 79.42,44.63 80.15,43.9 80.15,43.3 80.3,43.15 82.1,43.15 v1(82.1,42.55) ; v2(51.5,13.4) 51.5,13.75 51.78,14.03 C61.1 52.43,17.53 C62.2 ; 59.89,53.85 59.2,53.85 58.69,54.36 v2(58.62,54.36) ; UNK4U9.M7 50.01,42.71 50.3,43 ; 64.51,60.96 64.51,59.86 64.35,59.7 64.35,56.25 v1(64.51,56.09)
  TOP w0.25: v1(73.72,42.64) U1.N15 U1.M14 ; UNK4R52.1 v2(47.78,55.05) 48.36,55.05 48.36,53.24 48.64,52.96 UNK4U5.40 48.64,50.31 48.9,50.05 50.64,50.05 ; U1.M4 66.54,43.92 v1(66.57,43.92) ; U1.M4 65.92,43.95 U1.L4 ; U1.M4 65.96,43.34 ; v1(69.12,43.98) 69.17,43.98 69.47,44.27 U1.L9 ; v1(69.12,43.98) 68.84,44.26 U1.L8 ; v1(69.12,43.98) 69.48,43.62 U1.M9 ; 52.49,52.99 52.14,52.64 UNK4U5.33 52.14,50.29 51.9,50.05 50.64,50.05 ; U1.K12 71.12,44.6 v1(71.12,44.59) 70.79,44.27 U1.L11 ; U1.K12 71.77,44.6 ; U1.K12 71.77,45.24 71.77,45.24 U1.K13 ; U1.K12 v1(71.12,45.24) U1.J11 ; v2(45.8,49.8) 45.64,49.96 UNK4U5.46 ; C4.2 30.6,4.65 v2(29.8,4.65) U2.4 ; v2(50.75,30.35) 50.64,30.46 UNK4U5.13 50.64,32.94 50.65,32.95 ; 56.14,50.06 UNK4U5.25 56.14,52.14 56.4,52.4 ; UNK4U5.27 55.14,52.19 UNK4C11.1 ; 45.14,32.74 UNK4U5.2 45.14,30.26 ; 50.64,50.05 UNK4U5.36 50.64,51.97 ; 55.64,30.44 UNK4U5.23 55.64,32.84 ; v2(44.7,49.8) 44.64,49.86 UNK4U5.48 44.64,52.31 44.6,52.35 ; U1.P8 68.84,42.32 v1(68.51,42.64) 68.19,42.97 U1.N7 v1(67.86,42.64) 67.54,42.97 U1.N6 ; UNK3U1.M9 70.6,26.33 v1(70.61,26.34) v1(72.92,26.34)
  TOP w0.254: U1.E10 v1(70.47,48.5) 70.47,48.49 U1.E11 ; U1.E10 70.47,47.85 ; U1.E10 69.82,47.85 ; U1.E10 v1(69.82,48.5) ; 70.47,47.85 U1.F10 ; 70.47,47.85 v1(70.46,47.86) ; 70.47,47.85 U1.F11 ; 70.47,47.85 U1.E11 ; 71.12,43.94 v1(71.19,43.94) ; 71.12,43.94 U1.L11 v1(70.47,44.59) ; 71.12,43.94 U1.M12 71.77,43.94 ; 71.12,43.94 U1.L12 ; U1.T9 69.49,41.02 v1(69.78,41.32) ; 67.54,44.92 67.75,45.13 67.75,45.13 ; 67.54,44.92 U1.K6 67.75,45.13 ; 67.54,44.92 67.22,44.59 ; 67.54,44.92 v1(67.86,44.59) ; U1.H11 v1(71.12,46.55) ; U1.H11 70.47,45.9 ; U1.H11 71.12,45.9 U1.J11 70.47,45.9 ; U1.H11 70.47,46.55 ; v1(71.12,46.55) U1.G12 71.76,46.55 71.77,46.55 U1.G13 ; v1(71.12,46.55) 71.11,46.55 U1.G11 ; U1.F8 69,47.68 ; U1.F8 v1(68.51,47.2) ; U1.F8 v1(69.16,47.2) ; U1.F8 69,47.68 ; U1.F8 v1(68.51,47.85) ; 69,47.68 v1(69.16,47.85) ; 69.82,47.85 U1.F10 ; 69.82,47.85 69.65,48.01 ; 69.82,47.85 v1(69.82,47.86) ; 69.82,47.85 U1.F9 ; U1.F10 69.82,47.2 ; U1.F10 70.47,47.2 ; 73.07,40.7 U1.T15 ; v1(65.26,45.24) U1.K2 ; U1.N10 v1(69.82,42.64) U1.N9 ; U1.N10 69.82,43.29 ; U1.N10 v1(70.47,42.64) U1.P11 ; 72.42,43.29 72.42,43.3 U1.M14 ; 72.42,43.29 U1.M14 ; 72.42,43.29 U1.M13 ; v1(72.8,51.36) 72.79,51.36 72.79,51.51 72.75,51.55 72.74,51.54 ; U1.K7 v1(67.86,44.59) ; U1.K7 67.86,45.24 ; U1.K7 68.51,44.59 ; U1.K7 v1(68.51,45.24) ; v1(67.86,44.59) U1.L7 ; v1(67.86,44.59) U1.L6 ; v1(73.07,47.85) 72.74,47.52 ; 72.74,47.52 U1.F14 ; 72.74,47.52 U1.F14 ; v1(71.12,48.5) U1.D12 71.77,48.5 ; v1(71.12,48.5) U1.E11 ; v1(71.12,48.5) U1.E12 ; v1(71.12,48.5) U1.E12 ; 67.21,43.94 U1.M5 ; 67.21,43.94 66.9,44.28 ; 67.21,43.94 U1.L6 ; U1.M5 U1.N6 v1(67.21,42.64) ; U1.M5 66.58,43.93 ; 52.49,52.99 UNK4C10.1 52.49,54.33 v2(53.05,54.33) ; 65.26,42.64 65.27,42.64 ; 65.26,42.64 65.27,42.64 65.38,42.75 ; 65.26,42.64 64.94,42.97 ; 65.26,42.64 65.26,42.65 ; 65.26,42.64 U1.P2 ; 65.27,42.64 65.6,42.96 ; 65.27,42.64 65.59,42.32 ; 65.27,42.64 U1.P2 ; U1.G9 v1(69.16,46.55) ; U1.G9 69.82,46.55 ; U1.G9 v1(69.16,47.2) ; U1.G9 69.82,47.2 ; v1(69.16,46.55) U1.H8 ; v1(69.16,46.55) U1.G8 ; v1(69.16,46.55) U1.H9 ; 67.86,45.9 U1.H7 ; 67.86,45.9 U1.H6 ; 67.86,45.9 U1.J7 ; U1.H7 v1(68.51,46.55) ; U1.H7 68.51,45.9 ; U1.G13 v1(72.42,47.2) U1.F14 ; U1.G13 U1.H14 ; v1(71.17,40.74) 71.12,40.7 U1.T12 ; U1.E6 U1.F7 ; U1.E6 67.22,47.85 v1(67.21,47.85) U1.E5 ; U1.E6 v1(67.21,48.5) ; U1.E6 v1(67.86,48.5) ; U1.F7 v1(68.51,47.85) ; U1.F7 67.86,47.85 U1.E7 ; U1.F7 68.35,47.36 ; U1.G10 69.82,46.55 ; U1.G10 70.47,46.55 ; U1.G10 70.47,47.2 ; U1.G10 69.82,47.2 ; 69.82,46.55 U1.H10 ; 69.82,46.55 v1(69.85,46.54) ; 69.82,46.55 U1.H9 ; U1.H10 70.47,46.55 ; U1.H10 70.47,45.9 ; U1.H10 69.82,45.9 ; U1.J8 v1(68.51,45.24) ; U1.J8 v1(69.16,45.24) ; U1.J8 68.51,45.9 ; U1.J8 69.16,45.9 ; v1(68.51,45.24) U1.J7 ; v1(68.51,45.24) U1.K8 ; U1.E5 v1(66.56,48.5) ; U1.E5 66.56,47.85 ; U1.E5 67.21,48.49 v1(67.21,48.5) ; v1(66.56,48.5) 66.89,48.82 U1.D5 ; v1(66.56,48.5) 66.24,48.17 ; U1.T1 64.08,41.02 63.27,40.21 63.27,40.07 ; v1(69.16,48.5) 69.17,48.5 ; 69.17,48.5 U1.E9 ; 69.17,48.5 U1.D9 ; 69.17,48.5 U1.E8 ; v1(68.51,47.85) U1.E8 ; v1(68.51,47.85) U1.E7 ; U1.E8 v1(68.51,48.5) ; U1.E8 v1(69.16,47.85) ; U1.K10 v1(69.82,45.24) ; U1.K10 69.82,44.59 ; U1.K10 v1(70.47,44.59) ; v1(69.82,45.24) U1.J9 ; v1(69.82,45.24) U1.J10 ; v1(69.82,45.24) U1.K9 ; v1(68.51,47.2) 68.19,46.87 U1.G7 v1(68.51,46.55) ; v1(68.51,47.2) U1.G8 ; v1(68.51,47.2) 68.35,47.36 ; v1(68.51,47.2) 68.35,47.36 ; U1.E9 v1(69.16,47.85) ; U1.E9 69.65,48.01 ; U1.E9 v1(69.82,48.5) ; U1.E9 69.65,48.01 ; v1(69.16,47.85) U1.F9 ; U1.E7 v1(67.86,48.5) ; U1.E7 v1(68.51,48.5) ; U1.B17 75.23,50.12 v1(75.23,50.04) ; v1(69.16,47.2) U1.G8 ; v1(69.16,47.2) 69.17,47.2 U1.F9 ; 65.59,42.97 65.36,43.2 65.18,43.2 64.94,42.97 ; 65.59,42.97 U1.N3 ; 65.59,42.97 65.59,42.97 ; 65.59,42.97 65.59,42.97 ; 65.59,42.97 65.38,42.75 ; 65.59,42.97 U1.N3 ; 65.59,42.97 65.59,42.97 ; U1.G8 68.68,46.71 ; 70.47,47.2 v1(70.46,47.2) ; 70.47,47.2 U1.G11 ; 70.47,47.2 U1.F11 ; U1.L7 v1(67.86,43.94) ; U1.L7 68.51,43.95 68.52,43.95 U1.L8 ; U1.L7 68.51,44.59 ; v1(67.86,43.94) U1.L6 ; v1(67.86,43.94) U1.L6 ; 67.22,44.59 66.9,44.28 ; 67.22,44.59 67.38,44.43 ; 67.22,44.59 U1.K5 66.57,45.24 v1(66.56,45.24) ; 66.9,44.28 U1.L5 66.89,44.26 ; 66.9,44.28 66.89,44.26 ; 72.22,44.79 U1.K13 ; 72.22,44.79 v1(72.42,44.59) ; 72.22,44.79 v1(72.42,44.59) ; U1.K13 71.77,44.6 U1.L12 ; U1.K13 U1.J14 73.06,45.9 ; U1.N9 69.16,42.64 ; U1.N9 69.82,43.29 ; 66.24,48.17 v1(65.91,48.5) ; 66.24,48.17 U1.E4 ; 66.24,48.17 66.24,48.17 ; U1.J9 69.16,45.9 ; U1.J9 69.82,45.9 ; U1.J9 v1(69.16,45.24) ; 70.47,46.55 U1.G11 ; 70.47,45.9 U1.J10 ; 66.56,47.85 U1.F4 v1(65.91,47.85) ; 66.56,47.85 U1.E4 ; 69.16,45.9 U1.H9 ; 69.16,45.9 U1.H8 ; 66.57,43.94 66.89,44.26 ; 66.57,43.94 U1.L4 ; 66.57,43.94 v1(66.57,43.92) 66.58,43.93 ; 66.57,43.94 66.58,43.93 ; 66.89,44.26 66.58,43.93 ; 69.82,44.59 U1.K9 ; 69.82,44.59 U1.L9 ; 69.82,44.59 70.14,44.27 ; v1(72.42,43.94) 72.74,43.62 ; v1(72.42,43.94) 72.74,44.27 ; v1(72.42,43.94) U1.M13 ; 72.74,43.62 U1.M14 ; 72.74,43.62 72.74,43.62 U1.M14 ; 72.74,43.62 v1(73.07,43.94) ; U1.H14 v1(73.07,46.55) 73.38,46.23 U1.H15 ; U1.H14 73.06,45.9 ; 64.94,42.97 65.26,42.65 ; 64.94,42.97 U1.N2 64.94,42.97 ; 64.94,42.97 64.94,42.97 ; 65.26,42.65 U1.P3 ; 65.26,42.65 65.38,42.75 ; 67.86,45.24 v1(67.89,45.21) ; 67.86,45.24 67.75,45.13 ; 67.86,45.24 U1.J7 ; v1(69.16,45.24) U1.K9 ; v1(69.16,45.24) U1.K8 ; 50.64,51.97 50.9,52.22 v2(50.9,52.73) ; 68.68,46.71 v1(68.51,46.55) ; 68.68,46.71 v1(68.51,46.55) ; U1.L6 67.38,44.43 ; U1.L6 67.38,44.43 ; U1.L6 67.38,44.43 ; v1(68.51,46.55) U1.H8 ; v1(65.91,47.85) 66.24,48.17 ; v1(65.91,47.85) 65.91,47.84 U1.F3 65.27,47.2 ; 66.24,48.17 U1.E4 ; v1(68.51,48.5) U1.D7 ; U1.N3 65.6,42.96 ; U1.N3 65.59,42.97 ; U1.N3 65.59,42.97 ; v1(72.42,44.59) 72.41,44.59 ; v1(72.42,44.59) U1.L14 ; U1.H9 69.82,45.9 ; v1(65.91,41.99) 65.91,41.99 65.59,41.67 ; v1(65.91,41.99) U1.P4 ; v1(65.91,41.99) 65.59,42.32 ; U1.E13 71.77,47.85 U1.E12 ; U1.E13 v1(72.47,48.55) U1.D14 72.8,48.88 v1(72.51,49.18) ; U1.E13 72.41,47.85 v1(72.41,47.86) 72.59,47.68 72.59,47.67 U1.F14 ; U1.E13 71.77,48.5 ; U1.T5 66.57,40.7 v1(66.56,40.69) ; 71.77,48.5 U1.E12 ; U1.E12 71.12,47.85 ; 65.6,42.96 66.19,42.37 ; 65.6,42.96 65.59,42.97 ; v1(70.47,41.99) v1(71.12,42.64) ; v1(70.47,44.59) 70.14,44.27 ; 72.74,51.54 U1.A14 ; 72.74,51.54 72.74,52.85 73.07,53.18 ; U1.J7 68.51,45.9 ; 65.59,42.97 65.59,42.97 ; 65.59,42.97 65.38,42.75 ; 68.51,44.59 U1.K8 ; 68.51,44.59 U1.L8 ; v1(74.52,39.55) 74.52,39.58 74.04,40.06 U1.U16 ; U1.D5 v1(67.21,48.5) ; U1.D5 v1(66.56,49.15) ; U1.U6 67.54,40.01 67.69,39.52 ; 71.77,43.94 U1.M13 ; 71.77,43.94 U1.L12 ; 71.77,43.94 v1(71.75,43.94) ; 69.14,42.64 68.84,42.34 U1.P8 ; U1.F9 69.82,47.2 ; 73.06,45.9 U1.H15 ; U1.D7 v1(67.86,48.5) ; U1.D7 v1(67.86,49.15) ; v1(69.1,44.59) 69.16,44.59 ; 69.16,44.59 U1.K9 ; 69.16,44.59 U1.L9 ; 69.16,44.59 U1.K8 ; 69.16,44.59 U1.L8 ; U1.H8 68.51,45.9 ; 71.12,47.85 U1.F11 ; 71.12,47.85 U1.E11 ; 69.82,43.94 U1.M9 69.82,43.29 ; 69.82,43.94 70.14,44.27 ; 69.82,43.94 U1.L9 ; 65.59,42.32 65.91,42.64 66.19,42.37 ; 65.59,42.32 65.27,41.99 ; v1(73.72,43.94) U1.L15 73.07,43.95 v1(73.07,43.94) ; v1(69.16,49.15) 69.16,49.15 U1.D9 ; U1.J10 69.82,45.9 ; v1(69.82,47.2) 69.82,47.2 ; U1.U13 72.09,40.19 72.26,40.01 72.26,39.96 72.3,39.92 72.3,39.87 ; v1(69.82,48.5) U1.D9 ; U1.P4 v1(66.56,41.99) ; U1.P4 66.19,42.37 ; v1(73.07,43.94) 72.74,44.27 ; v1(70.2,39.88) 70.17,39.87 70.17,40.37 U1.U10 ; U1.R17 74.87,41.49 74.87,41.48 v1(75.56,41.48) ; U1.R3 65.59,41.67 ; 65.59,41.67 65.27,41.99 ; 65.59,41.67 v1(65.26,41.35) ; v1(75.41,43.44) 75.36,43.49 75.15,43.62 U1.M17 ; 65.27,41.99 U1.P2 ; U1.H15 v1(73.72,46.55) ; v1(65.3,39.27) 65.3,39.37 65.59,39.66 65.59,40.37 U1.U3 ; v1(71.12,44.59) U1.L12 ; 75.23,45.49 75.15,45.57 U1.J17 ; 73.08,42.65 73.39,42.97 U1.N15 73.07,42.65 73.07,42.64 72.74,42.32 U1.P14 v1(72.42,42.64) ; U1.A9 69.46,50.77 69.46,51.51 v1(69.36,51.62) ; 72.74,44.27 U1.L14 ; 72.74,44.27 U1.L14 ; v1(65.91,50.45) U1.B4 v1(66.56,49.8)
  TOP w0.3: v2(52,41.1) v2(52,39.65) 50.51,39.65 ; v2(52,41.1) UNK4U9.R10 v2(50.5,41.1) ; v2(52,41.1) v2(52,42.95) ; C71.2 63.78,18.54 ; C71.2 63.13,17.59 ; C71.2 63.13,19.49 ; C71.2 62.48,18.54 ; U52.2 45.75,10.8 ; 95.6,26.6 C257.2 ; C257.2 95.6,28.8 ; C257.2 94.85,27.7 ; v2(40.15,54) 40.15,54.45 ; 40.15,54.45 40.95,54.45 41.25,54.15 41.25,23.95 v2(41.35,23.85) ; 40.15,54.45 40.15,55.25 ; C2.2 83.15,15.1 ; C2.2 82.45,14.55 ; C2.2 C1.2 ; 71.77,44.6 U1.L13 ; U1.L13 72.09,44.27 v1(72.42,44.59) ; U1.L13 71.76,43.94 v1(71.75,43.94) ; U1.L13 v1(72.42,43.94) ; C73.2 63.78,16.61 ; C73.2 63.13,17.56 ; C73.2 63.13,15.66 ; C73.2 62.48,16.61 ; 42.4,25.2 41.85,25.75 41.85,55.15 41.35,55.65 40.55,55.65 40.15,55.25 ; C62.2 53.08,18.41 ; C62.2 51.78,18.41 ; C62.2 52.43,19.36 ; 49.41,41.6 UNK4U9.P5 48.75,41.6 v2(48.5,41.85) v2(48.5,42.6) 48.5,43.59 UNK4U9.K4 ; 63.3,32.73 UNK3U1.D1 ; 40.15,55.25 40.1,55.3 40.1,58.3 41.35,59.55 41.35,60.55 42.8,62 43.65,62 43.9,62.25 43.9,62.45 43.35,63 42.3,63 42.25,62.95 ; UNK3U1.B3 65.34,34.33 v1(64.97,33.96) ; C255.2 95.6,50.75 ; C255.2 95.6,48.55 ; C255.2 94.85,49.65 ; v1(64.23,28.4) 64.23,28.41 UNK3U1.J2 ; UNK5C11.1 78.18,43.66 v1(77.21,43.66) ; UNK5C11.1 77.95,43.4 ; UNK5C11.1 78.45,42.85 ; UNK4K2.2 14.62,16.79 ; UNK4K2.2 13.97,16.09 ; UNK4K2.2 13.32,16.79 ; UNK4K2.2 13.97,17.49 ; C355.2 35.2,57.45 ; C355.2 34.45,56.35 ; C355.2 34.45,58.55 ; 69.75,28.34 69.74,28.34 UNK3U1.J8 69.35,28.74 v1(68.95,29.14) ; 59.75,11.7 C69.1 ; C69.1 60.85,11.7 ; C69.1 60.3,12.2 ; v1(63.34,32.35) 63.75,31.94 ; 63.75,31.94 63.75,31.94 v1(64.14,32.34) UNK3U1.E2 ; 63.75,31.94 UNK3U1.E1 ; 22.85,2.45 R11.1 ; R11.1 22.85,3.55 ; R11.1 22.35,3 ; 46.3,38.2 46.7,38.6 UNK4U9.Y2 ; C6.2 32.3,11.55 ; C6.2 32.3,10.25 ; C6.2 31.35,10.9 ; C6.2 C7.2 ; C72.1 62.98,15.08 ; C72.1 62.48,15.63 ; C72.1 62.48,14.53 ; v1(83.08,42.8) 83.5,43.22 83.5,44.35 v1(83.15,44.35) 80.7,44.35 v1(80.5,44.55) ; UNK3U1.B9 UNK3U1.A9 70.15,35.41 v1(70.02,35.54) ; 54.95,10.8 U53.2 56.45,10.8 ; 70.9,65.21 UNK2D4.2 70.25,64.71 ; UNK4C5.2 46.6,29.3 ; UNK4C5.2 46.05,30 ; UNK4C5.2 46.05,28.6 ; UNK3U1.G8 69.72,30.7 v1(69.78,30.7) ; 50.51,40.5 UNK4U9.U8 50.51,39.7 ; C57.2 52.05,12.5 ; C57.2 51.1,11.85 ; C57.2 51.1,13.15 ; C57.2 50.15,12.5 ; U1.N2 v1(64.61,42.64) 64.62,42.64 U1.P2 ; 48.33,54.48 UNK4R52.1 47.23,54.48 ; v2(49.5,45.45) 49.51,45.44 ; UNK2Q1.2 65.75,64.1 ; UNK2Q1.2 66.35,63.5 ; UNK2Q1.2 65.15,63.5 ; UNK4K2.1 7.97,17.49 ; UNK4K2.1 8.62,16.79 ; UNK4K2.1 7.97,16.09 ; UNK4K2.1 7.32,16.79 ; v1(65.91,45.24) 65.92,45.24 U1.K4 ; C58.1 49.6,12.2 ; C58.1 50.15,11.7 ; C58.1 49.05,11.7 ; v1(73.07,49.8) 72.51,49.24 v1(72.51,49.18) ; v1(63.23,26.34) 63.24,26.33 UNK3U1.M1 ; 78.76,51.57 UNK2C9.1 ; 44.12,54.98 UNK4R2.1 44.67,54.48 ; C4.2 31.5,4.85 ; C4.2 30.8,5.4 ; C4.2 30.1,4.85 ; 42.25,62.95 42.25,62.35 41.62,61.73 39.98,61.73 39,60.75 39,52.4 38.8,52.2 38.8,51 39.45,50.35 39.45,38.55 v2(39.05,38.15) 39.05,37.65 38.8,37.4 38.25,37.4 37.85,37.8 37.85,38.4 38.75,39.3 v2(38.75,49.21) 38.75,49.7 38.2,50.25 38.2,52.55 38.4,52.75 38.4,57.85 37.6,58.65 v2(37.6,61) 37.6,61.65 38.95,63 42.2,63 42.25,62.95 ; v2(106.45,32.1) 115.2,32.1 ; 55.7,53.3 UNK4C11.1 56.2,52.75 ; UNK3U1.F9 70.6,31.13 ; 49.35,8.4 R60.1 49.85,7.85 ; 63.3,34.33 UNK3U1.B1 ; UNK2D3.2 61.55,65.71 ; UNK2D3.2 62.2,65.21 ; UNK2D3.2 60.9,65.21 ; UNK2D3.2 61.55,64.71 ; C11.1 24.85,5.45 v2(24.5,5.8) ; C11.1 24.35,4.4 ; C11.1 24.85,3.85 ; v2(106.49,54.1) 115.2,54.1 ; UNK4C10.1 52.99,53.62 ; 82.71,50.36 UNK2Y2.2 ; UNK2Y2.2 83.61,51.16 ; UNK2Y2.2 82.71,51.97 ; 65.96,43.34 v1(65.96,43.33) 65.59,42.97 U1.N3 ; v1(67.21,42.64) U1.P5 v1(66.56,41.99) ; 82.05,41.45 UNK5R78.2 81.55,40.9 ; C256.2 95.6,59.55 ; C256.2 94.85,58.45 ; C256.2 95.6,57.35 ; 61.35,72.6 UNK2CON1.1 61.35,70.4 ; C353.2 35.2,35.5 ; C353.2 34.45,36.6 ; C353.2 34.45,34.4 ; v1(62.58,44.38) 62.27,44.38 62.1,44.55 58.48,44.55 UNK4C3.1 57.54,43.79 56,42.25 56,36.35 53.95,34.3 52.9,34.3 52.35,33.75 48.85,33.75 48.2,33.1 v2(48.2,32.95) ; 90.25,36.6 v2(90.3,36.55) 90.4,36.45 90.4,25.65 v2(91,25.05) ; U1.M13 71.77,43.3 U1.M12 ; v1(68.96,31.55) 68.97,31.55 UNK3U1.E8 68.95,32.33 v1(68.95,32.34) 68.96,32.34 UNK3U1.D8 ; 54.75,29.7 UNK4C4.1 ; UNK4C4.1 55.25,29.15 ; UNK4C4.1 55.25,30.25 ; 44.79,54.48 UNK4R13.1 ; UNK4R13.1 45.89,54.48 ; UNK4R13.1 45.34,54.98 ; U1.R8 68.6,41.43 v1(68.6,41.41) ; 73.15,60.25 UNK2C15.1 73.65,60 72.53,58.88 UNK2U2.1 ; 58.75,8.8 R63.1 59.25,8.25 ; C61.1 51.78,17.43 ; C9.1 38.05,11.55 ; C9.1 37.5,11.05 ; C9.1 36.95,11.55 ; U1.K4 66.24,44.92 v1(66.56,45.24) ; U1.K4 66.48,44.68 v1(66.54,44.68) ; UNK4U9.H6 49.51,45 ; UNK2R14.2 73.14,55.09 v3(72.84,54.79) ; C67.1 49.85,6.75 ; 61.8,11.85 C68.2 ; C68.2 60.85,12.5 ; C68.2 62.75,12.5 ; C356.2 35.2,48.65 ; C356.2 34.45,47.55 ; C356.2 34.45,49.75 ; 88.3,47.6 88.3,33.35 89,32.65 v2(89,29) ; C1.2 85.25,14.55 ; C1.2 84.55,15.1 ; v1(66.54,44.68) 66.65,44.68 U1.K5 ; v1(66.54,44.68) 66.54,44.62 U1.L5 ; C8.2 36,11.55 ; C8.2 36.95,10.9 ; C8.2 C7.2 ; C8.2 36,10.25 ; UNK3U1.G9 70.6,30.33 ; 59.7,8.4 C75.1 60.25,7.9 ; v2(91.25,57.89) 91.1,58.04 91.1,59.35 91.85,60.1 91.85,60.8 91.45,61.2 90.75,61.2 v2(90.75,60.8) 90.75,60.25 90.5,60 90.5,56.35 ; C104.1 79.9,46.8 ; 34.45,25.6 C354.2 ; C354.2 35.2,26.7 ; C354.2 34.45,27.8 ; C258.2 95.6,37.6 ; C258.2 94.85,36.5 ; C258.2 95.6,35.4 ; C60.2 53.08,20.34 ; C60.2 52.43,19.39 ; C60.2 51.78,20.34 ; C60.2 52.43,21.29 ; 72.4,49.81 v1(73.07,49.15) 72.8,48.88 ; UNK3U1.T9 70.7,23.13 v1(70.71,23.14) ; UNK4U5.25 56.52,51.15 ; 34.1,10.25 C7.2 ; C7.2 34.1,11.55 ; 54.7,33.9 54.45,33.65 53.15,33.65 52.45,32.95 v2(49.15,32.95) ; v2(21.65,53.05) 13.85,53.05 ; 49.51,37.7 UNK4U9.AA6 ; 50.01,42.2 UNK4U9.M7 ; v2(21.55,31.1) 14.8,31.1 ; v1(64.11,22.77) 63.75,23.13 UNK3U1.T1 63.76,23.13 64.16,23.52 ; UNK4U9.T5 49.41,40.6 ; UNK5C3.1 v1(82.1,42.55) ; 80.41,52.11 UNK2Y2.4 79.51,52.91 ; UNK4U5.36 50.64,52.2 ; 48.51,37.7 UNK4U9.AA4 ; UNK2C3.1 79.26,50.98
  TOP w0.305: v1(69.78,30.7) 70.14,30.34 70.15,30.34 v1(70.63,30.33) ; v1(63.34,32.35) 63.73,32.74 63.75,32.74 64.14,32.34 v1(64.14,32.34) ; v3(72.84,54.79) 72.75,54.79 71.7,53.74 71.7,51.54 v1(71.56,51.4) ; v1(70.67,31.13) 70.67,31.14 70.15,31.14 69.78,30.77
  TOP w0.356: v1(78.74,53.91) 79.1,53.91 79.62,54.43 v1(80.34,54.43)
  TOP w0.381: 63.75,34.34 v1(63.39,34.67)
  TOP w0.4: UNK2Y2.2 82.44,51.16 v1(81.45,52.15) 80.69,52.91 UNK2Y2.4 80.19,52.7 v1(79.35,52.7) 78.77,52.12 ; v1(63.2,30.42) 63.29,30.33 UNK3U1.G1 ; v1(79.35,51.55) 78.77,51.55 ; 78.77,51.55 78.76,51.55 UNK2C3.1 ; 78.77,51.55 78.77,52.12 ; v1(70.72,24.73) 70.71,24.73 UNK3U1.P9 ; UNK2C9.1 78.77,52.12 ; UNK3U1.P1 63.2,24.73 v1(63.19,24.74) ; v2(7.75,1.2) 9.2,1.2 9.7,0.7 57.9,0.7 v2(57.95,0.75) 58,0.7 69,0.7 v2(69.3,1)
  TOP w0.406: v1(74.52,39.55) 76.27,37.8 v1(76.27,37.75) v1(76.27,35.69) v1(76.27,34.24) v1(76.27,32.51) v1(76.27,30.61) v1(76.27,28.86) v1(76.27,27.59) v1(76.27,26.39) 76.27,26.37 v1(75.18,25.28) v1(74.21,24.31) v1(73.4,23.5) v1(72.74,22.84) 71.7,21.8 v1(71.65,21.8) v1(70.01,21.8) v1(67.71,21.8) 66.21,21.8 v1(65.81,22.2) ; 63.17,28.22 v1(63.09,28.15) 62.53,27.59 62.53,26.85 61.82,26.14 v1(61.82,26.09) v1(61.82,24.41) v1(61.82,23.19) v1(62.78,22.23) v1(63.56,21.46) 65.12,19.89 v1(65.83,19.89) v1(67.64,19.89) v1(69.34,19.89) v1(71.09,19.89) v1(72.49,19.89) 78.15,25.55 78.15,39.07 ; v1(76.91,40.74) 76.91,41.94 76.35,42.5 75.36,43.49 ; v1(76.91,40.74) v1(77.87,39.78) 78.15,39.5 78.15,39.07 ; v1(76.91,40.74) 76.91,40.31 78.15,39.07 ; 75.09,51.28 v1(75.54,51.28) 75.54,51.68 ; 75.09,51.28 v1(74.77,51.28) ; 75.09,51.28 75.48,51.68 75.54,51.68 ; v1(63.19,42.52) v1(62.35,41.68) 61.54,40.87 v1(61.54,40.16) 61.54,37.24 v1(61.35,37.05) 60.75,36.45 v1(60.75,36.3) v1(60.75,34.19) v1(60.75,31.85) 60.75,31.79 62.44,30.1 62.44,28.97 63.17,28.25 ; 63.27,40.07 v1(63.27,38) v1(63.27,36.68) 63.27,36.43 62.48,35.64 v1(62.48,34.66) v1(62.48,33.33) 62.48,32.87 63,32.35 v1(63.34,32.35) ; v1(65.3,39.27) v1(65.3,38.2) v1(65.3,37.06) ; v1(66.49,39.07) v1(66.49,37.19) ; v1(67.1,54.55) v1(67.1,55.68) 67.1,60.5 67.7,61.1 v2(67.7,62.45) ; 73.38,29.47 v1(73.38,30.51) v1(73.38,32.26) v1(73.38,34.11) v1(73.38,35.46) 73.38,36.68 v1(73.33,36.73) v1(71.98,38.08) ; 73.38,29.47 v1(73.38,28.78) 72.69,28.78 ; 73.38,29.47 72.69,28.78 ; v1(67.52,33.78) 67.51,33.77 v1(67.51,32.67) v1(67.51,31.19) 67.11,30.79 v1(66.07,29.76) 65.93,29.62 65.93,29.14 66.61,29.14 ; 75.23,45.49 75.38,45.34 v1(75.92,45.34) v1(78.02,45.34) 79.71,45.34 v1(80.5,44.55) ; v1(69.36,58.3) v1(69.36,56.47) v1(69.36,54.74) v1(69.36,52.99) v1(69.36,51.62) ; v1(67.69,37.19) v1(67.69,38.41) v1(67.69,39.83) ; v1(64.4,39.88) 64.28,39.76 v1(64.28,38.38) v1(64.28,36.71) 64.28,36.48 v1(64.77,35.99) ; 72.5,39.66 72.3,39.87 ; 72.69,28.78 v1(72.49,28.58) ; v1(69.74,38.17) 69.74,38.15 ; v1(83.1,54) 82.55,54 82.11,54.43 v1(81.88,54.43) v1(80.34,54.43) ; 75.54,51.68 75.54,52.36 v1(77.12,53.95) 77.12,53.93 78.74,53.93 v1(78.74,53.91) ; v1(78.86,44.63) v1(76.37,44.63) ; v1(82.1,42.55) 82.83,42.55 v1(83.08,42.8) ; v1(65.96,51.72) 65.96,52.43 64.5,53.89 v1(64.5,54) 64.51,54.01 v1(64.51,54.75) v1(64.51,56.09) ; v1(65.2,51.67) 65.2,52.15 63.65,53.69 v1(63.65,54) 63.66,54.01 63.66,54.74 v1(63.65,54.75) 63.65,54.85 63.66,54.86 v1(63.66,56.09) v1(63.66,58.27) 63.66,59.14 62.9,59.9 62.9,60.45 63.41,60.96 v1(63.65,60.96) 64.51,60.96 ; v1(71.04,52.03) v1(71.04,53.52) 71.04,54.84 v1(71.51,55.31) ; 74.09,27.51 v1(74.09,28.59) v1(74.09,30.53) v1(74.09,32.26) v1(74.09,34.14) v1(74.09,35.51) 74.09,37.01 v1(74.06,37.04) v1(72.74,38.36) ; v1(72,30.09) 72.16,30.24 v1(72.16,32.16) v1(72.16,34.06) v1(72.16,35.91) 72.16,35.92 v1(71.12,36.96) ; v1(76.6,56.7) v1(74.97,55.08) v1(73.71,53.82) 73.27,53.38 73.07,53.18 ; 71.14,31.67 71.14,35.45 70.34,36.25 69.72,36.25 v1(69.29,36.68) v1(68.73,37.24) 68.7,37.26 v1(68.7,38.81) ; 71.14,31.67 71.14,30.84 v1(70.63,30.33) ; 71.14,31.67 70.61,31.14 ; v1(76.91,50.45) 76.71,50.45 76.3,50.04 v1(75.23,50.04) ; v1(67.92,54.55) v1(67.92,55.73) 67.92,60.17 68.7,60.95 68.7,61.95 68.9,62.15 v2(68.9,62.45) ; v1(63.2,30.42) v1(61.49,32.13) 61.46,32.16 v1(61.46,34.22) v1(61.46,35.99) 61.46,36.1 62.25,36.88 v1(62.25,37.1) 62.25,40.54 v1(63.24,41.53)
  TOP w0.5: v2(91.25,35.95) 91.25,37.35 92.2,38.3 92.2,47.3 v2(91.9,47.6) v2(91.9,49.2) v2(91.9,51.2) 91.9,56.65 91.25,57.3 v2(91.25,57.89) ; v2(83.1,74.2) 83.15,74.25 89.45,74.25 v2(89.5,74.2) ; v1(61.45,42.85) 57.75,42.85 56.7,41.8 56.7,35.9 54.7,33.9 ; v1(79.05,24.9) 79.05,22.65 v2(83.22,18.48) 84.1,17.6 86.45,17.6 88.4,15.65 v2(91.15,15.65) ; 90.5,56.35 90.95,55.9 v2(90.95,53.2) v2(90.95,52.2) v2(90.95,51.2) 90.95,47.55 v2(90.85,47.45) 90.8,47.4 v2(90.8,46.1) v2(90.8,44.85) 90.8,41.15 90.85,41.1 ; v2(86.8,40.4) v2(86.8,34.2) 86.8,32.35 87.25,31.9 v2(87.25,29.1) ; v2(85.8,46.15) 85.2,45.55 v2(85.2,40.4) v2(85.2,34.2) 85.2,31.5 85.3,31.4 v2(85.3,29.05) v2(85.3,26.4) ; UNK5C11.1 78.15,43.1 78.15,41.35 79.53,39.98 79.53,37.92 80.5,36.95 v2(80.5,29.6) v2(80.5,26.4) v2(80.5,23.6) 80.5,22.9 v2(83.7,19.7) 84.6,18.8 87,18.8 88.4,17.4 90.25,17.4 90.6,17.75 v2(91.15,17.75) ; C30.2 31.6,5.55 ; 42.75,74.25 57.4,74.25 ; v2(74.1,74.2) 74.15,74.25 79.65,74.25 v2(79.7,74.2) ; v2(86.25,29.05) 86.25,31.65 86,31.9 v2(86,34.2) v2(86,40.4) ; v2(87.6,44.85) v2(87.6,40.4) v2(87.6,34.2) 87.6,32.85 87.9,32.55
  TOP w1: C223.2 44.3,69.6 ; C223.2 45.65,72.15 ; C223.2 42.95,72.15 ; C205.2 52.75,72.15 ; C205.2 55.45,72.15 ; C205.2 54.1,69.6 ; 86.1,69.6 C323.2 ; C323.2 84.5,72.15 ; C323.2 87.45,72.15 ; C3.2 38.2,5.55 ; C3.2 36.6,6.6 ; C3.2 C30.2 33.2,6.6 ; C305.2 77.65,72.15 ; C305.2 74.95,72.15 ; C305.2 76.3,69.6
  MID1(L2) w0.3: 61.35,70.4 UNK2CON1.1 61.35,72.6
  MID2(L3) w0.3: 61.35,70.4 UNK2CON1.1 61.35,72.6
  BOTTOM w0.1: v2(37.1,25.75) 37.09,25.76 C322.1 ; v2(86.75,13.95) 86.7,13.9 86.7,10.85 87.35,10.2 88.35,10.2 88.75,9.8 ; 93.15,61.1 94.5,61.1 ; v2(104.5,32.1) v2(106.45,32.1) ; 37.59,60.99 v2(37.6,61) ; C253.1 93.45,24.15 v2(93.45,24.3) ; 72.84,19.89 74.04,19.89 v1(74.4,20.25) v1(75.4,21.25) v1(76.3,22.15) v1(77.2,23.05) v1(78.35,24.2) v1(79.05,24.9) 79.1,24.95 v1(79.1,26.2) v1(79.1,27.85) v1(79.1,29.6) v3(79.1,31.45) v3(79.1,33.3) v3(79.1,34.95) ; 71.08,26.95 71.08,26.95 UNK3R10.1 ; UNK4C2.1 64.15,45.24
  BOTTOM w0.102: 71.41,42.33 71.41,42.33 ; 71.41,42.33 71.41,42.29 ; 71.41,42.33 71.34,42.4 ; 71.41,42.33 71.41,42.37 71.38,42.4 ; 71.41,42.33 71.41,42.4 ; 71.41,42.33 71.41,42.3 ; 71.41,42.33 71.43,42.31 ; 67.39,42.38 67.36,42.41 ; 67.39,42.38 67.48,42.38 ; 67.39,42.38 67.57,42.19 ; 67.39,42.38 67.03,42.38 67,42.41 ; 67.36,42.41 67.45,42.41 ; 67.36,42.41 67,42.41 ; 67.36,42.41 67.18,42.59 ; 67.57,42.63 67.57,42.34 ; 67.57,42.34 67.3,42.61 67.28,42.61 ; 67.57,42.34 67.86,42.63 v1(67.86,42.64) ; 67.57,42.34 67.57,42.29 ; 73.04,42.51 72.71,42.19 72.71,42.22 ; 73.04,42.51 73.07,42.64 ; 73.04,42.51 73.16,42.63 ; v1(71.17,40.74) 71.52,41.1 71.52,41.51 71.41,41.62 71.41,42.17 ; 72.31,42.64 72.31,42.63 ; 72.31,42.63 72.44,42.51 72.44,42.49 72.51,42.42 ; 72.31,42.63 v1(72.42,42.64) 72.43,42.63 72.43,42.62 72.61,42.44 ; 72.31,42.63 72.3,42.64 ; 67.17,42.6 67.18,42.59 ; 67.18,42.59 v1(67.21,42.64) ; 67.18,42.59 67.23,42.59 ; 71.66,42.42 71.49,42.25 ; 71.66,42.42 72.51,42.42 ; 71.66,42.42 71.53,42.42 ; 71.66,42.42 71.75,42.51 71.75,42.62 ; 71.49,42.25 71.43,42.31 ; 71.49,42.25 71.42,42.18 ; 67.57,42.29 67.57,42.19 ; 67.57,42.29 67.45,42.41 ; 67.57,42.19 67.57,41.93 67.84,41.66 67.84,40.78 67.68,40.63 67.68,39.84 v1(67.69,39.83) ; 73.03,42.64 73.03,42.63 73.06,42.63 ; 73.03,42.64 73.07,42.64 ; 73.03,42.64 73.02,42.64 ; 73.03,42.64 73.02,42.64 72.89,42.51 72.71,42.33 ; 73.07,42.64 73.06,42.63 ; 73.07,42.64 73.16,42.63 ; 71.44,42.64 71.41,42.64 ; 71.44,42.64 71.77,42.64 ; 71.44,42.64 71.46,42.62 71.46,42.42 ; 71.41,42.64 71.19,42.64 ; 71.41,42.64 71.41,42.42 ; v1(68.6,41.41) 68.61,41.42 68.61,41.42 68.61,41.51 68.63,41.52 68.63,41.54 68.85,41.77 68.85,42.14 ; 66.9,26.84 v1(66.91,26.84) 67.43,26.84 67.93,26.34 69.73,26.34 ; 66.9,26.84 66.4,26.84 65.82,27.42 65.82,27.94 ; 66.9,26.84 67.04,27.07 68.51,27.07 68.63,26.95 71.08,26.95 ; 70.46,48.17 70.47,48.17 ; 66.51,29.26 v1(66.51,29.24) ; v1(72.16,27.26) 72.79,27.26 73.53,27.99 73.53,28.98 v1(73.38,28.78) ; 71.13,42.64 71.15,42.62 ; 71.13,42.64 71.19,42.64 ; 71.13,42.64 v1(71.12,42.64) 71.15,42.62 ; 71.28,42.32 71.21,42.4 ; 71.28,42.32 70.76,42.32 70.76,42.35 70.71,42.4 ; 71.28,42.32 71.41,42.2 ; 71.21,42.4 70.71,42.4 ; 71.21,42.4 71.12,42.49 71.12,42.62 71.34,42.4 ; 71.21,42.4 71.34,42.4 ; 72.71,42.33 72.71,42.35 ; 72.71,42.33 72.71,42.22 ; v1(71.98,38.08) 71.98,38.27 71.45,38.8 70.85,38.8 70.23,39.42 v1(70.2,39.88) ; 69.95,42.4 70.2,42.38 70.23,42.41 ; 69.95,42.4 69.9,42.43 ; 69.95,42.4 69.02,42.4 ; 69.95,42.4 70.36,41.97 ; 70.58,26.34 v1(70.61,26.34) ; 70.58,26.34 70.68,26.44 72.82,26.44 v1(72.92,26.34) ; 70.58,26.34 69.73,26.34 ; v1(67.21,42.64) 67.23,42.63 ; v1(67.21,42.64) 67.31,42.63 67.28,42.61 ; v1(67.21,42.64) 67.28,42.61 ; v1(67.21,42.64) 67.45,42.41 ; v1(67.21,42.64) 67.23,42.6 ; v1(67.21,42.64) 67.25,42.64 ; v1(67.21,42.64) 67.23,42.59 ; v1(65.26,41.35) 65.26,41.35 65.26,41.35 ; 70.36,41.97 v1(70.47,41.99) 70.49,42.02 70.4,42.02 70.36,41.97 ; 70.36,41.97 69.78,41.39 69.78,41.33 69.78,41.33 v1(69.78,41.32) ; 71.15,42.62 71.38,42.4 ; 71.38,42.4 71.34,42.4 ; 71.38,42.4 71.41,42.4 ; 72.51,42.42 72.59,42.42 72.61,42.44 ; 72.51,42.42 72.71,42.22 ; 71.41,42.42 71.41,42.4 ; 71.41,42.42 71.46,42.42 ; v1(66.56,40.69) 66.92,41.04 66.92,41.65 v1(66.56,41.99) 66.58,42.01 ; 68.85,42.57 68.85,42.64 ; 68.85,42.57 68.85,42.32 ; 68.85,42.57 68.88,42.55 68.88,42.38 ; 68.85,42.57 68.8,42.62 ; 67.23,42.59 67.23,42.6 ; 67.23,42.59 67.26,42.59 67.27,42.59 ; 71.41,42.29 71.41,42.2 ; 71.41,42.29 71.41,42.3 ; 68.97,30.08 68.52,30.52 68.52,31.4 ; 68.88,42.38 68.88,42.34 ; 68.88,42.38 68.92,42.38 ; 71.43,42.31 71.47,42.36 ; 71.43,42.31 71.41,42.3 ; 67,42.41 66.99,42.42 ; 70.21,42.43 69.9,42.43 ; 69.9,42.43 69.07,42.43 ; 69.9,42.43 69.82,42.52 69.82,42.62 ; 68.85,42.14 68.85,42.32 ; 68.85,42.14 68.8,42.19 ; 68.85,42.32 68.88,42.34 ; 68.85,42.32 68.83,42.29 ; 71.19,42.64 71.21,42.62 ; 71.53,42.42 71.74,42.62 ; 71.53,42.42 71.47,42.36 ; 71.53,42.42 71.46,42.42 ; 68.8,42.35 v1(68.51,42.64) ; 68.8,42.35 68.8,42.62 ; 68.8,42.35 68.8,42.31 ; 67.23,42.6 67.23,42.63 ; 67.23,42.6 67.26,42.6 ; 68.8,42.62 68.8,42.64 ; 69.07,42.43 69.02,42.4 ; 69.07,42.43 69.19,42.55 69.19,42.64 69.18,42.64 68.92,42.38 ; 69.02,42.4 68.92,42.38 ; 72.61,42.44 72.71,42.35 ; 65.82,27.94 64.69,27.94 v1(64.23,28.4) 63.72,28.91 63.72,29.09 63.37,29.44 63.37,30.62 63.46,30.72 UNK3C19.1 ; 65.82,27.94 65.82,28.19 65.94,28.31 v1(65.93,28.35) ; 73.06,42.63 73.16,42.63 ; 71.41,42.17 71.41,42.2 ; 71.41,42.17 71.42,42.18 ; 71.41,42.2 71.42,42.18 ; 68.88,42.34 68.92,42.38 ; 67.23,42.63 67.26,42.6 ; 67.27,42.59 67.28,42.61 ; 67.27,42.59 67.26,42.6 ; 68.97,29.12 68.97,29.16 v1(68.95,29.14) ; 68.8,42.19 68.47,42.52 68.47,42.64 68.8,42.31 ; 68.8,42.19 68.8,42.27 ; UNK5C10.1 75.31,44.99 76.02,44.99 v1(76.37,44.63) 76.37,44.55 77.21,43.72 v1(77.21,43.66) ; 70.51,42.62 70.49,42.64 v1(70.47,42.64) 70.71,42.4 ; 71.47,42.36 71.46,42.37 71.46,42.42 ; 68.8,42.31 68.8,42.27 ; 68.8,42.31 68.83,42.29 ; 72.71,42.35 72.71,42.64 ; 72.5,28.59 v1(72.49,28.58) 72.42,28.55 72.45,28.58 ; 68.8,42.27 68.83,42.29 ; v1(67.86,43.94) 67.48,43.56 67.48,42.64 ; 71.23,46.43 v1(71.12,46.55) ; 67.86,49.15 v1(67.86,49.15) 67.9,49.11 ; 69.73,26.34 69.73,25.92 69.29,25.48 67.55,25.48 67.1,25.92 67.09,25.9 ; 73.16,42.63 73.17,42.64 ; v1(71.12,45.24) 71.23,45.36 ; 70.72,30.34 v1(70.63,30.33) ; 67.28,35.99 67.24,36.03 67.24,36.13 66.49,36.88 v1(66.49,37.19)
  BOTTOM w0.127: v1(72.8,51.36) 72.58,51.59 72.58,52.95 72.92,53.29 v1(73.2,53.29) ; 74.95,51.46 v1(74.77,51.28) ; v1(66.51,29.24) 66.63,29.2 66.53,29.1 66.51,29.1 66.51,27.77 66.8,27.49 68,27.49 68.63,28.11 72.21,28.11 72.48,28.38 72.48,28.57
  BOTTOM w0.15: 85.62,22.98 87.22,22.98 ; 84.05,47.55 84.15,47.55 84.5,47.9 89.6,47.9 89.85,48.15 ; v1(60.85,51.25) 60.25,51.25 58.1,53.4 58.1,54.36 ; 41.63,52.83 44,55.2 52.6,55.2 53.85,53.95 55.8,53.95 57.25,52.5 ; 57.25,51.7 58.4,51.7 60,50.1 60,49.85 60.05,49.85 60.05,49.75 ; 42.4,54.4 43.7,55.7 52.91,55.7 54.16,54.45 56.35,54.45 60.25,50.55 v1(60.85,50.55)
  BOTTOM w0.152: 70.35,48.06 69.69,48.72 69.16,48.72
  BOTTOM w0.2: C332.1 39.81,54.86 40.35,55.4 42.6,55.4 43.4,56.2 53.11,56.2 54.36,54.95 57.51,54.95 58.1,54.36 v2(58.62,54.36) 59.13,53.85 59.75,53.85 59.9,54 ; R9.1 46.4,6.35 v2(45.7,6.35) ; 90.18,2.42 92.68,2.42 ; 90.18,2.42 90.18,3.73 ; 90.18,2.42 87.68,2.42 ; 90.18,2.42 90.18,1.27 ; 92.68,2.42 92.68,3.68 ; 92.68,2.42 93.38,2.42 ; 92.68,2.42 92.68,1.22 ; 87.68,2.42 87.68,1.37 ; 87.68,2.42 87.03,2.42 ; 87.68,2.42 87.68,3.83 ; v2(40.15,54) 40.55,54.4 42.4,54.4 ; 87.5,20.7 85.95,19.15 85.95,15.7 86.1,15.55 v2(86.1,12.9) ; 87.5,20.7 87.5,21.15 87.28,21.38 86.78,21.38 85.35,19.95 85.35,13.95 v2(85.4,13.9) ; 87.5,20.7 88.05,20.7 88.5,21.15 88.5,22.1 88.45,22.15 v2(87.25,22.15) ; C241.1 92.46,35.94 v2(92.45,35.95) ; C217.1 v2(93.35,57.14) ; 86.68,7.23 J813.15 85.75,8.1 ; v2(93.2,33.9) 93.24,33.86 U202.9 ; R7.1 44.05,5.2 v2(44.5,5.2) 44.8,5.5 45.7,5.5 ; C246.1 93.7,38.05 93.6,38.15 v2(93.3,38.15) ; v2(91.25,57.89) 91.24,57.88 C252.1 ; v2(86.75,13.95) 86.75,15.75 86.45,16.05 86.45,18.45 88,20 89,20 v2(89,20.85) ; 89.68,7.27 J813.9 89.68,8.87 88.75,9.8 ; 41.63,52.83 C342.2 ; v2(96.1,48.06) 96.12,48.08 R201.2 ; v2(36.85,51.25) 36.81,51.29 U302.9 ; 87.68,7.12 J813.13 87.68,8.67 87.4,8.95 85.3,8.95 84.15,10.1 84.15,13 83.95,13.2 83.95,14.9 84.45,15.4 v2(84.45,15.8) ; 92.68,7.17 J813.3 92.68,8.72 91.15,10.25 90.85,10.25 90.25,10.85 90.25,12.95 89.55,13.65 89.55,15.1 ; 85,48.7 87.65,48.7 ; v2(91.25,35.95) 91.24,35.94 C254.1 ; C317.1 37.59,27.79 v2(37.05,27.25) ; R301.2 33.93,37.06 v2(33.95,37.08) ; C204.1 v2(95.5,46.1) ; 57.25,51.7 57.25,52.5 ; 61.05,58.35 63.58,58.35 v1(63.66,58.27) ; v2(38.8,27.25) 38.81,27.26 C350.1 ; U201.9 v2(93.35,55.8) ; 89.5,15.1 90.25,15.85 UNK5D11.2 ; v2(96.1,38.1) 96.12,38.08 R223.1 ; v2(50.75,30.35) 50.95,30.15 UNK4C49.1 51.85,29.7
  BOTTOM w0.203: v1(71.04,53.52) 71.09,53.52 71.17,53.44 71.17,52.19 71.04,52.06 v1(71.04,52.03) ; v1(71.56,51.4) 71.73,51.56 71.73,55.09 v1(71.51,55.31) ; v1(69.82,42.64) 70.05,42.64 70.05,44.5 ; 68.97,30.08 70.15,30.08 70.4,30.34 v1(70.63,30.33) ; 71.1,42.62 v1(71.12,42.64)
  BOTTOM w0.25: 93.5,60 93.7,59.8 C222.1
  BOTTOM w0.254: 66.58,42.01 66.99,42.42 v1(67.21,42.64) ; 62.95,48.7 v1(61.87,49.79) ; 79.14,46.89 78.86,47.17 77.29,47.17 UNK2C17.2 ; 69.03,29.09 v1(68.95,29.14) ; 69.03,29.09 68.52,29.09 68.01,29.59 66.51,29.59 66.51,29.26 ; 69.03,29.09 70.96,29.09 71.32,29.44 71.32,30.34 ; C102.1 69.6,51.07 69.6,49.62 69.16,49.18 v1(69.16,49.15) v1(69.16,48.5) ; 67.86,49.15 67.86,49.14 67.9,49.11 ; 67.85,42.63 v1(67.86,42.64)
  BOTTOM w0.3: v2(35.17,53.04) v2(34.12,53.04) v2(33.12,53.04) ; 94.03,51.36 U201.1 ; U201.1 93.43,51.8 ; U201.1 94.68,51.8 95.18,52.3 ; 75.08,64.25 T321.1 75.83,63.5 ; UNK4C18.1 52.6,40.9 ; UNK4C18.1 52.6,39.8 ; UNK4C18.1 53.1,40.35 ; 99.7,4.83 J814.5 ; J814.5 100.15,5.75 ; J814.5 100.15,3.9 ; C359.1 17.6,56.9 ; C359.1 16.9,56.35 ; C359.1 18.3,56.35 ; 61.61,41.31 UNK3C28.2 ; UNK3C28.2 62.55,41.33 ; UNK3C28.2 61.59,40.37 ; v2(38.75,49.21) 38.81,49.27 C352.1 39.36,49.94 ; UNK2C16.1 69.64,46.32 ; UNK2C16.1 69.14,45.82 ; UNK2C16.1 69.64,45.32 ; 29.45,57.78 C331.2 30,57.08 ; C231.2 100,28.12 ; C231.2 100.55,27.42 ; C231.2 100,26.72 ; 100.55,22.55 C228.1 ; C14.1 44,12.2 ; C14.1 43.45,11.7 ; C14.1 44.55,11.7 ; 70.36,34.85 UNK3C58.1 ; U201.39 95.18,52.3 ; 95.18,52.3 95.68,52.8 ; UNK2R15.1 77.32,51.6 ; UNK2R15.1 76.81,51.1 ; UNK2R15.1 77.32,50.6 ; UNK2R15.1 77.82,51.1 ; 96.12,45.6 C204.1 96.67,46.1 ; 71.33,44.42 UNK5C9.1 ; UNK5C9.1 71.83,44.93 ; UNK5C9.1 72.33,44.42 ; UNK5C9.1 71.83,43.92 ; 34.87,54.79 34.37,54.29 ; 34.87,54.79 U302.39 ; 34.87,54.79 35.37,55.29 U302.1 ; 34.37,54.29 33.87,53.79 ; 34.37,54.29 U302.3 36.62,54.29 ; C342.2 39.1,53.53 ; C12.1 24.45,5.05 ; C12.1 23.9,5.55 ; C12.1 23.35,5.05 ; 90.95,53.55 C218.2 ; C218.2 90.4,54.25 ; C218.2 90.95,54.95 ; 51.66,17.46 C56.2 ; C56.2 52.31,18.41 ; C56.2 51.01,18.41 ; C56.2 51.66,19.36 ; 33.87,53.79 U302.4 36.62,53.79 ; 33.87,53.79 33.37,53.29 ; v2(36.85,29.3) 36.81,29.34 U301.9 34.87,29.34 v2(33.12,31.09) ; 47,41.95 UNK4C26.1 45.9,41.95 ; Q2.2 39.15,10.05 ; Q2.2 38.55,9.45 ; Q2.2 38.55,10.65 ; Q2.2 37.95,10.05 ; 100,36.1 C248.2 ; C248.2 100.55,36.8 ; C248.2 100,37.5 ; J814.10 J814.9 ; J814.10 100.3,0.95 ; J814.10 100.3,3.35 ; J814.10 99.15,2.15 ; J814.9 102.6,3.35 ; J814.9 103.75,2.15 ; J814.9 102.6,0.95 ; C219.1 106.17,59.02 ; C219.1 106.72,58.32 ; C219.1 106.17,57.62 ; C216.1 R205.2 ; C216.1 109.4,57.95 ; C216.1 108.7,57.4 ; R205.2 110.8,57.95 ; R205.2 111.5,57.4 ; T311.1 64.3,68.6 ; T311.1 63.55,67.85 ; T311.1 65.05,67.85 ; C207.1 106.72,49.78 ; C207.1 106.17,50.48 ; C207.1 106.17,49.08 ; 66.53,44.38 UNK3C39.1 ; UNK3C39.1 67.53,44.38 ; UNK3C39.1 67.03,43.87 ; UNK4C8.1 49.85,51.4 ; UNK4C8.1 48.75,51.4 ; UNK4C8.1 49.3,50.9 ; C232.1 91.61,30.83 ; C232.1 91.61,29.73 ; C232.1 91.11,30.28 ; Q4.2 86.65,27.85 ; Q4.2 86.05,28.45 ; Q4.2 85.45,27.85 ; 36.35,25.26 C322.1 35.8,25.76 ; 84.8,33.5 C78.2 84.1,32.95 ; UNK2C10.1 72.54,47 ; 105.2,46.7 C264.2 ; C264.2 104.65,47.4 ; C264.2 105.2,48.1 ; 36.62,32.34 U301.3 34.37,32.34 ; C224.2 100,59.5 ; C224.2 100.55,58.8 ; C224.2 100,58.1 ; 108,33.35 C240.1 ; C240.1 107.45,34.05 ; C240.1 R221.2 ; 51.15,41.55 UNK4C17.1 51.65,42.1 ; 118,51.5 R234.2 ; R234.2 118,52.9 ; R234.2 118.55,52.2 ; 64.8,51.13 UNK2C22.1 ; UNK2C22.1 65.3,51.63 ; UNK2C22.1 65.81,51.13 ; UNK3C46.1 64.18,22.05 ; UNK3C46.1 63.67,21.55 ; UNK3C46.1 63.17,22.05 ; UNK3C46.1 63.67,22.55 ; 97.65,0.95 J814.11 ; J814.11 98.8,2.15 ; J814.11 97.65,3.35 ; J814.11 96.5,2.15 ; 106.45,54.06 v2(104.55,54.06) ; 106.45,54.06 106.43,54.04 104.55,54.04 ; 106.45,54.06 v2(106.49,54.1) 106.45,54.14 106.45,55.06 104.54,55.06 104.54,54.3 U201.25 97.18,54.3 ; 46.05,67.85 T318.1 ; T318.1 47.55,67.85 ; T318.1 46.8,67.1 ; T318.1 46.8,68.6 ; 35.76,37.4 C301.2 v2(37.35,36.85) ; 24.9,36.9 C362.2 ; C362.2 25.45,37.6 ; C362.2 24.9,38.3 ; J813.S1 85.88,2.85 ; J813.S1 85.43,1.82 ; J813.S1 84.98,2.85 ; J813.S1 85.43,3.88 ; 23.88,56.6 C329.1 ; C329.1 23.88,58 ; C329.1 23.33,57.3 ; 23.88,34.66 C307.1 ; C307.1 23.88,36.06 ; C307.1 23.33,35.36 ; U54.2 81.3,35.55 ; 24.6,22.6 R340.2 ; R340.2 25.15,23.3 ; R340.2 24.6,24 ; UNK3C19.1 63.88,31.22 ; UNK3C19.1 63.88,30.21 ; UNK3C19.1 64.38,30.72 ; 40.52,20.34 C16.2 ; C16.2 41.17,19.39 ; C16.2 41.82,20.34 ; C16.2 41.17,21.29 ; 95.68,52.8 U201.3 93.43,52.8 ; 95.68,52.8 96.18,53.3 ; 45.1,50.9 UNK4C48.1 45.65,50.4 ; 23.33,26.82 C319.1 ; C319.1 23.88,26.12 ; C319.1 23.88,27.52 ; 52.1,53.5 UNK4R7.1 51.6,52.95 ; C76.2 80.85,39.7 ; C76.2 80.85,38.3 ; C76.2 80.3,39 ; 107.45,49 C259.1 108,49.7 ; 36.35,47.21 C346.1 ; C346.1 35.8,47.71 ; C346.1 36.9,47.71 ; 32.87,53.29 32.37,53.79 ; 32.87,53.29 U302.26 25.51,53.29 C335.2 ; 32.87,53.29 v2(33.12,53.04) ; 32.37,53.79 U302.34 ; 32.37,53.79 31.37,54.79 U302.29 v2(29.41,54.79) ; 70.03,35.52 UNK3C20.1 ; UNK3C20.1 69.52,36.02 ; UNK3C20.1 70.53,36.02 ; 55.85,4.95 C66.1 55.3,5.45 ; 51.66,19.39 C54.2 ; C54.2 52.31,20.34 ; C54.2 51.01,20.34 ; C54.2 51.66,21.29 ; v2(94.88,54.05) v2(95.93,54.05) v2(96.93,54.05) ; 24.9,38.6 R339.1 ; R339.1 24.9,40 ; R339.1 25.45,39.3 ; UNK5R64.2 78.21,45.05 ; UNK5R64.2 77.7,44.55 ; UNK5R64.2 78.21,44.05 ; UNK5R64.2 78.71,44.55 ; 104.65,24 C268.2 ; C268.2 105.2,23.3 ; C268.2 105.2,24.7 ; v2(96.93,54.05) 96.68,53.8 ; v2(96.93,54.05) 97.18,54.3 ; v2(96.93,54.05) 97.18,53.8 ; v2(96.93,54.05) 95.18,55.8 U201.9 ; 96.68,53.8 U201.5 93.43,53.8 ; 96.68,53.8 96.18,53.3 ; C250.1 52.75,70.65 ; C250.1 52.75,69.55 ; C250.1 53.25,70.1 ; C79.2 59.05,35.55 ; C79.2 59.05,34.15 ; C79.2 59.6,34.85 ; 105.09,55.07 C214.2 104.54,55.77 ; UNK3C18.1 62.97,26.52 ; UNK3C18.1 61.97,26.52 ; UNK3C18.1 62.47,26.01 ; 106.45,33.12 C238.2 ; C238.2 104.54,32.36 U202.25 97.18,32.36 ; C238.2 104.54,33.82 ; UNK2C11.1 63.41,44.83 ; UNK2C11.1 62.41,44.83 ; UNK2C11.1 62.91,45.34 ; R319.1 C333.2 ; R319.1 19.2,56.9 ; R319.1 18.5,56.35 ; C333.2 20.6,56.9 ; C333.2 21.3,56.35 ; v2(37.25,49.15) 37.59,49.49 C341.1 37.04,49.94 ; C245.1 100.65,41.7 ; 58.55,67.85 T313.1 ; T313.1 59.3,68.6 ; T313.1 60.05,67.85 ; 95.68,30.86 94.68,29.86 U202.1 ; 95.68,30.86 96.18,31.36 ; 95.68,30.86 U202.3 93.43,30.86 ; C206.2 100.55,49.42 ; C206.2 100,50.12 ; C206.2 100,48.72 ; v2(55.5,63.3) 55.2,63.6 UNK2T25.1 ; C18.2 41.17,19.36 ; C18.2 41.82,18.41 ; C18.2 41.17,17.46 ; C18.2 40.52,18.41 ; UNK3C35.1 62.97,24.44 ; UNK3C35.1 62.47,23.93 ; UNK3C35.1 61.97,24.44 ; UNK3C35.1 62.47,24.94 ; 52.32,16.33 C55.1 ; C55.1 52.32,17.43 ; C55.1 51.82,16.88 ; C208.1 91.61,52.77 ; C208.1 91.61,51.67 ; C208.1 91.11,52.22 ; T320.1 75.83,60.96 ; T320.1 75.08,61.71 ; T320.1 74.33,60.96 ; T320.1 75.08,60.21 ; T312.1 62.55,67.85 ; T312.1 61.8,68.6 ; T312.1 61.05,67.85 ; UNK2C6.2 60.88,48.64 ; UNK2C6.2 60.2,49.3 ; UNK2C6.2 59.52,48.64 ; 62.49,30.19 UNK3C27.1 ; UNK3C27.1 62.99,30.7 ; UNK3C27.1 61.99,30.7 ; UNK3C27.1 62.49,31.2 ; 64.52,30.5 UNK3C26.2 ; UNK3C26.2 65.88,30.5 ; UNK3C26.2 65.2,31.16 ; 32.87,52.79 32.37,52.29 U302.17 ; 32.87,52.79 v2(33.12,53.04) ; 32.87,52.79 U302.25 25.51,52.79 25.51,52.03 23.6,52.03 23.6,53.03 ; v2(100.65,55.8) U201.22 98.68,55.8 97.68,54.8 ; R304.1 C309.2 ; R304.1 22,35.15 ; R304.1 22.55,34.45 ; C309.2 22.55,33.05 ; C309.2 22,32.35 ; v2(37.15,39.65) 37.15,39.04 C349.1 ; 49.65,38.35 UNK4C35.1 49.1,37.85 ; v2(84.45,15.8) 84.8,16.15 84.8,20.4 86,21.6 v2(86,22.35) ; 63.16,34.2 UNK3C21.1 ; UNK3C21.1 64.16,34.2 ; UNK3C21.1 63.66,34.7 ; UNK3C21.1 63.66,33.69 ; 68.78,32.35 UNK3C38.1 ; UNK3C38.1 69.29,32.85 ; UNK3C38.1 68.28,32.85 ; UNK3C38.1 68.78,33.35 ; 69.59,43.99 UNK3R6.1 ; UNK3R6.1 69.09,44.5 ; UNK3R6.1 70.09,44.5 ; UNK3R6.1 69.59,45 ; v2(31.07,29.64) 30.77,29.34 U301.22 v2(29.35,29.34) ; 97.05,4.7 J814.7 ; J814.7 99.65,4.7 ; J814.7 98.35,3.65 ; J814.7 98.35,5.75 ; 66.07,34.81 UNK3C10.1 ; UNK3C10.1 65.56,35.31 ; UNK3C10.1 66.07,35.81 ; 107.45,27.15 C261.1 108,27.85 ; R221.2 108,36.15 ; R221.2 107.45,35.45 ; Q5.2 80.45,28.45 ; Q5.2 81.05,27.85 ; Q5.2 80.45,27.25 ; Q5.2 79.85,27.85 ; 90.95,31.61 C242.2 ; C242.2 90.95,33.01 ; C242.2 90.4,32.31 ; C316.1 22,29.85 ; C316.1 22.55,29.15 ; C316.1 R305.2 ; 64.36,42.93 UNK3C31.1 63.64,42.21 ; 46.5,62.85 UNK2T17.1 ; UNK2T17.1 45.75,63.6 ; UNK2T17.1 47.25,63.6 ; 54.6,7.15 C65.1 55.15,7.65 ; C367.1 19.7,46.4 ; C367.1 19.15,47.1 ; C367.1 19.15,45.7 ; 89.75,16.7 UNK5D11.2 90.25,17.35 ; 63.47,26.19 UNK3C6.2 ; UNK3C6.2 64.15,25.54 ; UNK3C6.2 64.83,26.19 ; 97.18,32.36 97.68,32.86 ; 97.18,32.36 v2(96.93,32.11) ; UNK3C8.2 67.28,32.51 ; UNK3C8.2 66.6,31.85 ; UNK3C8.2 67.28,31.2 ; C221.1 93.8,62.5 ; C221.1 93.25,61.8 ; C221.1 93.8,61.1 ; 68.1,45.35 UNK2C20.1 68.6,45.85 ; C340.1 22,51.8 ; C340.1 22.55,51.1 ; C340.1 R321.2 ; UNK4R9.2 45.85,41.8 ; UNK4R9.2 45.3,42.3 ; UNK4R9.2 44.75,41.8 ; 24.96,52.02 C338.2 25.51,51.32 ; UNK2T28.1 v2(57.35,61.6) ; 106.17,27.14 C229.1 ; C229.1 106.17,28.54 ; C229.1 106.72,27.84 ; UNK4C47.2 50.9,38.9 ; UNK4C47.2 51.6,38.35 ; UNK4C47.2 50.2,38.35 ; 103.65,6.45 UNK5C13.1 ; UNK5C13.1 104.15,7 ; UNK5C13.1 103.65,7.55 ; 23.6,53.03 v2(23.6,53.05) v2(25.5,53.05) ; 23.6,53.03 25.5,53.03 ; 43.65,31.25 C22.2 ; C22.2 45.05,31.25 ; C22.2 44.35,31.8 ; 24.75,5.4 R3.1 ; R3.1 25.25,4.85 ; R3.1 25.25,5.95 ; v2(93.35,48.29) C201.2 94.29,47.74 ; C249.2 53.3,72.1 ; C249.2 53.3,70.7 ; C249.2 53.85,71.4 ; 39.65,30.89 C318.2 39.1,31.59 ; 53,11.85 C51.2 ; C51.2 52.05,12.5 ; C51.2 53,13.15 ; C51.2 53.95,12.5 ; C335.2 24.96,54.05 ; C335.2 25.51,54.75 ; UNK2C17.2 77.72,47.42 ; 107.45,28.75 R220.1 ; R220.1 108,28.05 ; R220.1 C233.2 ; C308.1 38.95,32.92 ; C308.1 38.45,32.37 ; C308.1 38.45,33.47 ; 38.2,13.25 Q3.2 ; Q3.2 39.4,13.25 ; Q3.2 38.8,13.85 ; Q3.2 38.8,12.65 ; 53.95,11.7 C52.1 ; C52.1 54.5,12.2 ; C52.1 55.05,11.7 ; R341.1 14.35,59.65 ; R341.1 15.05,59.1 ; R341.1 13.65,59.1 ; 97.76,53.22 98.68,52.3 U201.29 v2(100.65,52.3) ; 97.76,53.22 97.18,53.8 ; 97.76,53.22 97.68,53.14 U201.34 ; 97.68,32.86 U202.17 ; 97.68,32.86 98.68,33.86 U202.22 v2(100.65,33.86) ; 68.79,33.46 UNK3C42.1 ; UNK3C42.1 68.29,33.96 ; UNK3C42.1 69.3,33.96 ; 96.12,23.65 C226.1 v2(95.5,24.15) 95.35,24.15 ; 90.69,35.2 C254.1 ; UNK3C11.1 64.5,31.85 ; UNK3C11.1 63.49,31.85 ; UNK3C11.1 63.99,31.35 ; UNK3C11.1 63.99,32.35 ; 104.65,40.2 C269.1 ; C269.1 105.2,39.5 ; C269.1 105.2,40.9 ; C260.2 115.75,55.4 ; C260.2 115.2,54.7 ; C260.2 115.2,56.1 ; 71.55,43.31 UNK3C4.1 ; UNK3C4.1 72.06,42.81 ; UNK3C4.1 72.06,43.81 ; UNK3C4.1 72.56,43.31 ; v2(33.12,53.04) 33.37,53.29 ; v2(33.12,53.04) 34.87,51.29 U302.9 ; 29.45,48.4 C348.2 30,49.1 ; 22,35.2 C357.1 ; C357.1 22.55,35.9 ; C357.1 22,36.6 ; 94.25,37.43 C246.1 93.15,37.43 ; 105.2,45.1 R233.1 ; R233.1 104.65,45.8 ; R233.1 105.2,46.5 ; 22.55,26.3 C358.2 22,27 ; 34.37,32.34 34.87,32.84 ; 34.37,32.34 33.87,31.84 ; 64.57,43.01 UNK3C62.1 65.29,43.01 ; U302.1 36.02,55.73 ; U302.1 36.62,55.29 ; 93.43,31.36 U202.4 96.18,31.36 ; 76.1,42.42 C101.1 75.6,42.92 ; 94.29,25.79 C230.2 93.36,26.34 v2(93.35,26.35) ; v2(33.12,31.09) 33.37,31.34 ; v2(33.12,31.09) 32.87,31.34 ; v2(33.12,31.09) v2(34.12,31.09) v2(35.17,31.09) ; v2(33.12,31.09) 32.87,30.84 U301.25 25.51,30.84 25.51,30.08 23.6,30.08 v2(23.6,31.1) v2(25.5,31.1) ; 104.54,31.86 C235.2 ; 104.54,31.86 104.54,32.06 v2(104.5,32.1) ; 104.54,31.86 U202.26 97.18,31.86 ; C235.2 104.54,30.39 ; C235.2 105.09,31.09 ; 22,27.05 R305.2 ; R305.2 22.55,27.75 ; 36.62,31.84 U301.4 33.87,31.84 ; 32.37,31.84 32.87,31.34 ; 32.37,31.84 31.37,32.84 U301.29 v2(29.35,32.84) ; 32.37,31.84 U301.34 ; 32.87,31.34 U301.26 25.51,31.34 C311.2 ; 60.89,30.7 UNK3R20.1 ; UNK3R20.1 61.39,31.2 ; UNK3R20.1 61.39,30.19 ; v2(96.93,32.11) 95.18,33.86 U202.9 ; v2(96.93,32.11) v2(95.88,32.11) v2(94.88,32.11) ; v2(96.93,32.11) 96.68,31.86 ; v2(96.93,32.11) 97.18,31.86 ; 38.45,54.31 C332.1 38.45,55.41 ; 96.18,31.36 96.68,31.86 ; 63.65,45.21 UNK4C2.1 64.65,45.21 ; 62.02,32.76 UNK3C2.1 ; UNK3C2.1 62.52,33.26 ; UNK3C2.1 62.52,32.25 ; UNK3C2.1 63.02,32.76 ; v2(95.05,59.75) 95.4,59.4 96.12,59.4 R207.1 95.57,59.38 ; C20.1 44.9,8.35 ; C20.1 44.9,7.25 ; C20.1 45.4,7.8 ; 33.37,31.34 U301.5 36.62,31.34 ; 33.37,31.34 33.87,31.84 ; 97.68,54.8 97.18,54.3 ; 97.68,54.8 U201.17 ; UNK3C5.1 68.98,44.78 ; UNK3C5.1 67.98,44.78 ; UNK3C5.1 68.48,45.28 ; UNK3C5.1 68.48,44.27 ; 49.35,10.8 U3.2 47.85,10.8 ; 61.35,72.6 UNK2CON1.1 61.35,70.4 ; C209.2 R204.1 ; C209.2 107.45,52.15 ; C209.2 108,52.85 ; R204.1 108,50.05 ; R204.1 107.45,50.75 ; 85.72,61.38 86.2,60.9 90.65,60.9 v2(90.75,60.8) 90.75,59.9 91.65,59.9 91.9,60.15 91.9,61.05 91.45,61.5 86.8,61.5 85.85,62.45 ; 24.96,30.07 C314.2 25.51,29.37 ; 103.25,4.7 J814.6 ; J814.6 104.55,5.75 ; J814.6 104.55,3.65 ; UNK2C4.2 61.9,49.3 ; UNK2C4.2 62.58,48.64 ; UNK2C4.2 61.22,48.64 ; 56.05,67.85 T314.1 ; T314.1 56.8,68.6 ; T314.1 57.55,67.85 ; 107.45,30.15 C233.2 ; C233.2 108,30.85 ; C17.1 41.82,17.43 ; C17.1 41.82,16.33 ; C17.1 41.32,16.88 ; 96.18,53.3 U201.4 93.43,53.3 ; v2(29.44,51.29) U302.22 30.77,51.29 v2(31.07,51.59) ; C217.1 92.46,57.64 ; U301.1 36.02,33.78 ; U301.1 35.37,33.34 34.87,32.84 ; U301.1 36.62,33.34 ; 55.25,7.35 R59.1 ; C106.1 83.3,49.65 ; C106.1 82.2,49.65 ; C106.1 82.75,50.15 ; UNK4C34.1 51.65,43.2 ; 34.87,32.84 U301.39 ; C262.2 108,37.75 ; C262.2 108,36.35 ; C262.2 107.45,37.05 ; 97.18,53.8 U201.26 104.54,53.8 C211.2 ; 69.9,36.07 v1(69.29,36.68) ; 94.48,2.85 J813.S5 ; J813.S5 94.93,3.88 ; J813.S5 95.38,2.85 ; J813.S5 94.93,1.82 ; 93.15,59.38 C222.1 ; U202.1 93.43,29.86 ; U202.1 94.03,29.42 ; 105.2,24.9 R235.1 ; R235.1 104.65,25.6 ; R235.1 105.2,26.3 ; 84.15,43.65 C103.1 ; C103.1 83.6,44.15 ; C103.1 84.7,44.15 ; C265.1 118,54.5 ; C265.1 118,53.1 ; C265.1 118.55,53.8 ; 96.68,31.86 U202.5 93.43,31.86 ; 100.6,44.5 C203.1 ; 104.1,2.15 J814.8 ; J814.8 105.25,0.95 ; J814.8 105.25,3.35 ; C351.1 37.59,60.99 ; 23.33,48.77 C343.1 ; C343.1 23.88,49.47 ; C343.1 23.88,48.07 ; C77.2 53.1,33.2 ; C77.2 51.7,33.2 ; C77.2 52.4,32.65 ; 60.9,43.99 UNK2C13.2 61.58,44.64 ; UNK3C9.1 63.45,35.31 ; UNK3C9.1 62.94,35.81 ; UNK3C9.1 62.44,35.31 ; UNK3C9.1 62.94,34.81 ; 92.05,16.05 UNK5D12.2 ; UNK5D12.2 92.55,16.7 ; UNK5D12.2 92.05,17.35 ; C311.2 24.96,32.11 ; C311.2 25.51,32.81 ; 29.45,35.78 C306.2 30,35.08 ; R342.2 19.7,44.75 ; R342.2 19.15,45.45 ; R342.2 19.15,44.05 ; 29.45,21.55 C321.1 ; T315.1 55.05,67.85 ; T315.1 53.55,67.85 ; T315.1 54.3,68.6 ; 41.55,12.5 C13.2 ; C13.2 42.5,13.15 ; C13.2 43.45,12.5 ; C13.2 42.5,11.85 ; UNK4C9.1 55.05,31.1 ; UNK4C9.1 54.55,31.65 ; UNK4C9.1 54.55,30.55 ; U202.34 97.68,31.36 ; 97.68,31.36 98.68,30.36 U202.29 v2(100.65,30.36) ; 97.68,31.36 97.18,31.86 ; 55.85,33.9 U55.2 ; 29.45,43.5 C345.1 ; 22,49 R321.2 ; R321.2 22.55,49.7 ; 33.37,53.29 U302.5 36.62,53.29 ; 34.48,39.04 C304.1 33.93,39.72 v2(33.85,39.8) ; 44.05,32.95 C21.2 ; C21.2 44.05,34.35 ; C21.2 44.6,33.65 ; 37.04,28 C317.1 ; C303.1 29.5,40.6 ; 90.69,57.14 C252.1 ; 29.45,26.4 C324.2 30,27.1 ; v1(80.34,54.43) 80.34,54.87 77.16,58.04 71.54,58.04 71.15,57.65 71.15,55.95 70.85,55.65 70.85,55 71.04,54.81 v1(71.04,53.52) ; R7.1 44.6,5.85 ; 19.15,47.4 C360.2 19.85,47.95 ; 58.35,10.8 U51.2 59.85,10.8 ; C363.1 24.6,25.5 ; C363.1 25.15,24.8 ; C363.1 24.6,24.1 ; 34.48,60.99 C326.1 v2(33.93,61.7) 34,61.7 ; C366.2 16.65,59.1 ; C366.2 15.25,59.1 ; C366.2 15.95,59.65 ; C243.1 106.17,37.07 ; C243.1 106.17,35.67 ; C243.1 106.72,36.37 ; 45.85,7.35 R9.1 ; U202.39 95.18,29.81 ; 105.2,37.9 R236.2 ; R236.2 104.65,38.6 ; R236.2 105.2,39.3 ; C350.1 39.36,28 ; UNK3C45.1 69.59,29.62 ; UNK3C45.1 69.08,30.12 ; UNK3C45.1 69.08,29.12 ; UNK3C45.1 68.58,29.62 ; C328.1 29.5,62.55 ; v2(36.8,58.8) C330.2 35.76,59.35 ; C211.2 104.54,52.34 ; C211.2 105.09,53.04 ; C241.1 93.01,35.2 ; 83.05,46.8 C105.1 82.5,46.3 ; 66.59,25.9 UNK3C40.1 ; U301.17 32.37,28.97 ; T308.1 72.55,67.85
  BOTTOM w0.305: v1(83.08,46.87) 86.63,46.87 87.4,46.1 C251.1 ; UNK3C1.1 73.99,46.56 72.26,46.56 UNK2C10.1 ; 71.23,44.43 71.23,46.43 ; v1(70.02,35.54) 70.02,35.17 68.8,33.95 68.8,33.96 68.79,33.96
  BOTTOM w0.381: v1(63.19,24.74) 62.77,24.74 62.47,24.44 62.47,24.41 v1(61.82,24.41) ; 71.21,42.62 71.74,42.62 ; 71.21,42.62 71.12,42.62 ; 71.21,42.62 71.14,42.64 ; 72.71,42.51 73.39,42.51 ; 73.72,42.19 73.72,42.14 ; 73.72,42.19 73.26,42.64 ; 73.72,42.19 v1(73.72,42.64) ; 73.72,42.14 74.12,42.54 ; 73.72,42.14 v1(73.72,41.99) ; 70.49,42.62 70.95,42.62 ; 70.49,42.62 v1(70.47,42.64) ; 70.49,42.62 70.02,42.62 ; v1(77.12,53.95) 77.11,53.96 77.11,54.05 ; 73.26,42.64 v1(72.42,42.64) 71.77,42.64 ; 73.26,42.64 v1(73.72,42.64) ; v1(73.72,42.64) 74.19,42.64 ; 69.82,42.62 v1(69.82,42.64) ; 69.82,42.62 70.02,42.62 ; 69.82,42.62 69.51,42.62 69.49,42.64 ; 75.56,42.19 v1(75.56,41.48) ; 75.56,42.19 75.22,42.53 75.16,42.53 75.15,42.54 74.12,42.54 ; 75.56,42.19 75.56,42.27 75.18,42.64 74.19,42.64 ; 71.77,42.64 71.74,42.62 ; 71.77,42.64 71.77,42.62 71.74,42.62 ; 74.19,42.64 74.19,42.61 74.12,42.54 ; 71.12,42.62 v1(71.12,42.64) ; 71.12,42.62 70.95,42.62 ; 70.02,42.62 70.47,42.17 70.5,42.17 ; 70.47,42.14 70.72,42.39 70.72,42.4 70.95,42.62
  BOTTOM w0.4: v1(70.72,24.73) 71.1,24.73 UNK3C30.1 ; C78.2 v2(83.2,33.5) ; v1(61.92,30.61) 61.83,30.7 UNK3R20.1 ; UNK2C17.2 76.88,47.58 UNK2C12.1 ; v1(62.28,27.31) 62.47,27.11 UNK3C18.1 ; UNK3C58.1 70.86,35.71 v1(70.86,35.71) ; v1(64.51,54.75) v1(63.65,54.75) ; UNK3C12.1 70.66,23.19 v1(70.71,23.14) ; UNK2C13.2 62.19,43.99 v1(62.58,44.38) 62.91,44.7 UNK2C11.1 ; v1(64.5,54) v1(63.65,54) ; C102.1 69.62,51.36 v1(69.36,51.62) ; C206.2 99.95,49.37 99.95,49.31 ; C224.2 99.96,58.8 99.95,58.79 ; U54.2 v2(81.3,33.8) ; UNK4C34.1 UNK4C17.1 ; v1(63.23,26.34) 64,26.34 UNK3C6.2 64.41,25.94 v1(64.94,25.94)
  BOTTOM w0.406: 67.25,42.64 v1(67.86,42.64) v1(68.51,42.64) 69.18,42.64 ; v1(65.81,22.2) 66.21,21.8 v1(67.71,21.8) ; v1(63.65,54.75) 59.95,54.75 v2(59.43,55.27) 58.62,54.46 v2(58.62,54.36) ; 65.26,41.42 64.4,40.56 v1(64.4,39.88) ; 65.26,41.42 65.3,41.38 v1(65.3,39.27) v1(65.3,38.2) v1(65.3,37.06) ; 65.26,41.42 65.81,41.97 65.89,41.97 v1(65.91,41.99) v1(66.56,41.99) ; 65.26,41.42 65.26,41.35 ; v3(72.84,54.79) 72.84,53.66 73.2,53.3 v1(73.2,53.29) ; 72.08,30.01 71.75,30.34 70.72,30.34 ; 72.08,30.01 v1(72,30.09) ; 72.08,30.01 72.61,29.47 72.61,28.7 72.5,28.59 ; v1(69.36,52.99) v1(69.36,54.74) v1(69.36,56.47) ; 73.38,36.68 v1(73.33,36.73) v1(71.98,38.08) ; 73.38,36.68 73.36,36.68 71.24,38.8 ; 73.38,36.68 v1(73.38,35.46) v1(73.38,34.11) v1(73.38,32.26) v1(73.38,30.51) 73.38,29.12 ; UNK2C11.1 63.32,45.24 v1(65.26,45.24) v1(65.91,45.24) v1(66.56,45.24) ; v1(74.09,28.59) v1(74.09,30.53) v1(74.09,32.26) v1(74.09,34.14) v1(74.09,35.51) 74.09,37.01 v1(74.06,37.04) v1(72.74,38.36) ; v1(64.97,33.96) 66.06,35.05 66.06,35.77 65.83,35.99 v1(64.77,35.99) ; 59.9,54 62.4,54 62.4,54 v1(63.65,54) ; v1(70.2,39.88) 69.78,40.32 v1(69.78,41.32) ; 68.72,38.8 70.18,37.33 70.73,37.33 ; 68.72,38.8 68.72,39.35 ; 68.72,38.8 v1(68.7,38.81) 68.7,39.36 68.72,39.35 ; 68.72,39.35 70.73,37.33 ; 68.72,39.35 68.72,41.32 68.61,41.42 ; v3(79.1,34.95) 78.95,35.1 78.43,35.1 ; v1(72.74,22.84) v1(73.4,23.5) v1(74.21,24.31) v1(75.18,25.28) 76.27,26.37 v1(76.27,26.39) v1(76.27,27.59) v1(76.27,28.86) v1(76.27,30.61) v1(76.27,32.51) v1(76.27,34.24) v1(76.27,35.69) v1(76.27,37.75) 76.27,37.8 v1(74.52,39.55) ; v1(70.67,31.13) 71.15,31.13 72.16,32.13 v1(72.16,32.16) v1(72.16,34.06) v1(72.16,35.91) 70.73,37.33 ; v1(69.82,42.64) 69.19,42.64 ; 73.38,29.12 v1(73.38,28.78) 73.38,29.12 ; v1(70.86,35.71) 70.86,35.73 70.52,36.07 69.9,36.07 ; 67.23,42.63 67.85,42.63 ; v1(71.65,21.8) v1(70.01,21.8) ; v1(62.23,29.03) 62.3,29.03 64.14,27.19 64.96,27.19 v1(66.04,26.11) 66.25,25.9 67.05,25.9 67.09,25.9 ; v1(82.1,42.55) 80.35,44.3 80.35,45.68 79.14,46.89 ; UNK3C1.1 75.01,47.58 UNK2C12.1 ; v1(72.8,51.36) 72.8,51.92 73.53,52.65 73.55,52.63 ; v1(70.47,41.99) v1(70.47,42.64) ; v1(71.17,40.74) 71.42,40.74 v1(72.51,39.65) ; v1(72.16,27.26) 71.61,27.26 UNK3R10.1 ; 78.43,35.1 v1(78.43,34.19) v1(78.43,32.51) v1(78.43,30.61) v1(78.43,28.83) v1(78.43,26.9) 78.43,25.48 v1(78.28,25.33) v1(77.03,24.08) v1(74.24,21.29) 72.84,19.89 v1(72.49,19.89) v1(71.09,19.89) v1(69.34,19.89) v1(67.64,19.89) v1(65.83,19.89) 65.07,19.89 v1(64.74,20.22) ; 78.43,35.1 v1(78.43,35.69) v1(78.43,37.8) 78.43,39.21 76.16,41.48 v1(75.56,41.48) ; v1(66.56,40.69) 66.49,40.62 v1(66.49,39.07) v1(66.49,37.19) ; v1(69.29,36.68) v1(68.73,37.24) 67.68,38.28 v1(67.69,39.83) ; 67.28,35.99 68.4,34.88 68.4,34.36 68.79,33.96 ; v1(72.49,28.58) 72.45,28.58
  BOTTOM w0.5: v2(100.55,47.84) v2(100.55,48.44) v2(99.95,48.44) ; v2(100.55,47.84) v2(99.95,47.84) v2(99.95,48.44) ; v2(100.55,47.84) v2(99.95,48.44) ; v2(29.5,59.25) v2(30.1,59.25) v2(30.1,58.65) ; v2(29.5,59.25) v2(29.5,58.65) v2(30.1,58.65) ; v2(29.5,59.25) v2(30.1,58.65) ; 85.85,62.45 85.15,63.15 82.5,63.15 81.37,64.28 v2(81.37,68.63) 79.6,70.4 73.1,70.4 71.7,69 68.8,69 68.1,68.3 68.1,67.5 67,66.4 v2(63.7,66.4) v2(61.5,66.4) v2(59.9,66.4) v2(58.3,66.4) v2(56.5,66.4) 52.35,66.4 51.8,65.85 43.2,65.85 41,63.65 41,62.15 41.3,61.85 42.2,61.85 42.2,63.65 43.6,65.05 52.2,65.05 52.75,65.6 v2(56.5,65.6) v2(58.3,65.6) v2(59.9,65.6) v2(60.7,65.6) v2(63,65.6) 67.75,65.6 v2(68.4,66.25) 68.75,66.6 69.3,66.6 v2(70.5,67.8) 70.55,67.85 T308.1 73.5,69.55 v2(79.25,69.55) 80.5,68.3 80.5,63.95 82.15,62.3 84.8,62.3 85.72,61.38 ; v2(82.6,60.75) 82.8,60.55 84.55,60.55 85,60.1 88.8,60.1 89.25,59.65 90.5,59.65 90.75,59.9 ; v2(30.1,58.65) 30,58.55 C331.2 ; C306.2 30,36.6 v2(30.1,36.7) ; v2(30.1,25.48) v2(30.1,24.88) v2(29.5,24.88) ; v2(30.1,25.48) v2(29.5,24.88) ; v2(30.1,25.48) 30,25.58 C324.2 ; v2(30.1,25.48) v2(29.5,25.48) v2(29.5,24.88) ; v2(99.95,26.5) v2(100.55,26.5) v2(100.55,25.9) ; v2(99.95,26.5) 99.95,27.37 C231.2 ; v2(99.95,26.5) v2(100.55,25.9) ; v2(99.95,26.5) v2(99.95,25.9) v2(100.55,25.9) ; v2(29.5,46.83) v2(30.1,46.83) v2(30.1,47.43) ; v2(29.5,46.83) v2(29.5,47.43) v2(30.1,47.43) ; v2(29.5,46.83) v2(30.1,47.43) ; v2(30.1,47.43) 30,47.53 C348.2 ; v2(30.1,36.7) v2(30.1,37.3) v2(29.5,37.3) ; v2(30.1,36.7) v2(29.5,36.7) v2(29.5,37.3) ; v2(30.1,36.7) v2(29.5,37.3) ; v2(100.55,38.32) v2(99.95,38.32) v2(99.95,37.72) ; v2(100.55,38.32) v2(100.55,37.72) v2(99.95,37.72) ; v2(100.55,38.32) v2(99.95,37.72) ; v2(99.95,59.66) v2(100.55,60.26) ; v2(99.95,59.66) 99.95,58.79 ; v2(99.95,59.66) v2(100.55,59.66) v2(100.55,60.26) ; v2(99.95,59.66) v2(99.95,60.26) v2(100.55,60.26) ; U55.2 v2(57.3,33.9) ; v2(99.95,37.72) 99.95,36.85 C248.2 ; v2(91.25,29) 91.25,26.75 90.1,25.6 86.5,25.6 85.7,26.4 v2(85.3,26.4) ; v2(99.95,48.44) 99.95,49.31
  BOTTOM w0.635: v1(69.82,48.5) 69.93,48.48 70.72,48.48 ; 70.46,48.17 70.35,48.06 ; 72.04,48.48 72.02,48.45 70.75,48.45 ; 72.04,48.48 70.72,48.48 ; 72.04,48.48 72.94,49.38 ; 70.72,48.48 70.75,48.45 ; 70.75,48.45 70.47,48.17
  BOTTOM w1.016: 70.25,48.16 70.46,48.16
  vias: v1(56.4,52.8) v1(59.5,61.6) v1(60.63,30.23) v1(60.6,28.6) v1(60.68,26.14) v1(62.78,35.92) v1(63.7,63.6) v1(70.65,57.25) v1(72.41,45.24) v1(72.7,60) v1(76.6,42.25) v1(81.9,32.75) v1(83.1,37.9) v1(83.65,42.45) v1(83.65,41) v1(85.15,44.15) v2(7.3,59.8) v2(7.3,55.8) v2(7.3,52.6) v2(7.3,49.6) v2(7.3,46) v2(7.3,42.6) v2(7.3,39.2) v2(7.3,36) v2(7.3,32.8) v2(7.3,29.6) v2(7.3,26.8) v2(7.3,24.2) v2(7.3,21.6) v2(7.3,18.4) v2(7.3,15.6) v2(7.3,12.15) v2(7.3,8) v2(7.3,5.4) v2(7.3,2.8) v2(7.7,62.4) v2(9.3,63) v2(9.7,49.6) v2(9.7,46) v2(9.7,42.6) v2(9.9,26.8) v2(10.1,39) v2(10.1,36) v2(10.1,32.8) v2(10.1,0.8) v2(10.3,61) v2(10.3,57.6) v2(10.3,56) v2(10.3,54) v2(10.3,52.4) v2(11.5,63) v2(12.9,61) v2(12.9,57.6) v2(12.9,56) v2(12.9,54) v2(13.9,63.8) v2(14.3,60) v2(14.4,55.3) v2(15.1,0.8) v2(15.3,61) v2(15.7,65.2) v2(15.9,17.6) v2(15.9,15.6) v2(15.9,13.6) v2(15.9,11.8) v2(15.9,10) v2(15.9,8.2) v2(16.1,43.6) v2(16.1,42) v2(16.1,40.6) v2(16.1,39.2) v2(16.7,20) v2(16.9,67) v2(16.9,63.8) v2(16.9,61) v2(16.9,42) v2(16.9,39.2) v2(17.5,73.6) v2(17.5,71.4) v2(17.5,69) v2(17.7,42.05) v2(17.7,17.6) v2(17.7,15.6) v2(17.7,13.6) v2(17.7,11.8) v2(17.7,10) v2(17.7,8.2) v2(17.7,6.6) v2(17.7,4.8) v2(17.7,3) v2(18.3,20) v2(18.5,74.2) v2(19.3,19) v2(19.5,17.6) v2(19.5,15.6) v2(19.5,13.6) v2(19.5,11.8) v2(19.5,10) v2(19.5,8.2) v2(19.5,6.6) v2(19.5,4.8) v2(19.5,3) v2(19.65,42.05) v2(19.9,20) v2(20.1,0.8) v2(21.1,20) v2(21.3,74.15) v2(21.7,15.6) v2(21.7,13.6) v2(21.7,11.8) v2(21.7,10) v2(21.7,8.2) v2(21.7,6.6) v2(22.15,42.05) v2(22.45,31.1) v2(22.5,20) v2(22.5,0.8) v2(22.7,18) v2(22.7,16.95) v2(23.9,13.6) v2(23.9,11.8) v2(23.9,10) v2(24.1,20.2) v2(24.3,18) v2(24.7,74.2) v2(24.7,42.05) v2(25.1,0.8) v2(26.5,20.2) v2(26.6,42.05) v2(26.9,18) v2(27.7,74.2) v2(28.1,63.6) v2(28.1,62.75) v2(28.1,43.3) v2(28.1,42.7) v2(28.1,42.1) v2(28.1,41.45) v2(28.1,40.8) v2(28.1,21.6) v2(28.35,3.4) v2(28.7,63.6) v2(28.7,62.75) v2(28.7,43.3) v2(28.7,42.7) v2(28.7,42.1) v2(28.7,41.45) v2(28.7,40.8) v2(28.7,21.6) v2(29.5,63.6) v2(29.5,62.75) v2(29.5,43.3) v2(29.5,42.7) v2(29.5,42.1) v2(29.5,41.45) v2(29.5,40.8) v2(29.8,5.25) v2(30.1,72.2) v2(30.1,70.2) v2(30.1,68.2) v2(30.1,65.2) v2(30.1,63.6) v2(30.1,62.75) v2(30.1,0.8) v2(30.3,43.3) v2(30.3,42.7) v2(30.3,42.1) v2(30.3,41.45) v2(30.3,40.8) v2(31.1,74.2) v2(31.07,54.49) v2(31.07,53.74) v2(31.07,53.04) v2(31.07,52.34) v2(31.07,32.54) v2(31.07,31.79) v2(31.07,31.09) v2(31.07,30.39) v2(31.5,72.2) v2(31.5,70.2) v2(31.5,68.2) v2(31.5,66.8) v2(32.12,54.49) v2(32.12,53.74) v2(32.12,53.04) v2(32.12,52.34) v2(32.12,51.59) v2(32.12,32.54) v2(32.12,31.79) v2(32.12,31.09) v2(32.12,30.39) v2(32.12,29.64) v2(32.9,72.2) v2(32.9,70.2) v2(32.9,68.2) v2(33.12,54.49) v2(33.12,53.74) v2(33.12,52.34) v2(33.12,51.59) v2(33.12,32.54) v2(33.12,31.79) v2(33.12,30.39) v2(33.12,29.64) v2(33.9,44) v2(33.9,41.8) v2(34.12,54.49) v2(34.12,53.74) v2(34.12,52.34) v2(34.12,51.59) v2(34.12,32.54) v2(34.12,31.79) v2(34.12,30.39) v2(34.12,29.64) v2(34.3,74.2) v2(34.3,9.2) v2(34.3,8.2) v2(34.3,7.2) v2(34.9,72.2) v2(34.9,70.2) v2(34.9,68.2) v2(35.1,0.8) v2(35.17,54.49) v2(35.17,53.74) v2(35.17,52.34) v2(35.17,51.59) v2(35.17,32.54) v2(35.17,31.79) v2(35.17,30.39) v2(35.17,29.64) v2(35.3,9.2) v2(35.3,8.2) v2(35.3,7.2) v2(36.15,63.05) v2(36.3,46.8) v2(36.3,9.2) v2(36.3,8.2) v2(36.3,7.2) v2(36.4,23.6) v2(36.5,42.6) v2(36.5,41) v2(37.3,72.2) v2(37.3,70.2) v2(37.3,68.2) v2(37.5,74.2) v2(38.3,20.8) v2(38.5,46.8) v2(38.5,43.4) v2(38.7,5.25) v2(38.7,4.65) v2(38.9,35.6) v2(38.95,20.9) v2(39.7,72.2) v2(39.7,70.2) v2(39.7,68.2) v2(39.7,5.25) v2(39.7,4.65) v2(39.8,23.6) v2(40.1,0.8) v2(40.3,18.4) v2(40.5,74.2) v2(40.55,13.85) v2(40.7,21.6) v2(40.9,5.25) v2(40.9,4.65) v2(41.5,13.4) v2(42.3,24.2) v2(42.9,74.2) v2(42.9,14.6) v2(44.05,59.1) v2(44.3,24) v2(44.3,14.8) v2(44.4,52.55) v2(44.5,22.05) v2(44.7,48.2) v2(44.7,13.4) v2(44.9,45.1) v2(44.9,43.5) v2(45.1,0.8) v2(45.7,74.2) v2(45.9,48.2) v2(47,45.1) v2(47.2,62.35) v2(47.3,59.8) v2(47.9,34.4) v2(48.1,47.6) v2(48.1,27.4) v2(48.51,37.6) v2(48.45,5.7) v2(49.1,5.8) v2(49.2,47.55) v2(49.3,74.2) v2(49.3,72.2) v2(49.3,70.6) v2(49.35,22.05) v2(49.4,14.55) v2(49.4,13.85) v2(49.4,13.15) v2(49.5,59.8) v2(49.5,41.1) v2(49.51,36) v2(49.7,12.6) v2(49.9,4.8) v2(50.1,27.4) v2(50.1,0.8) v2(50.3,35.2) v2(50.3,14.6) v2(50.3,13.85) v2(51.3,7.4) v2(51.5,14.2) v2(51.7,36.3) v2(51.9,6.4) v2(51.9,4.8) v2(51.95,23.4) v2(51.95,22.45) v2(51.95,21.55) v2(52.3,59.8) v2(52.3,13.4) v2(52.7,74.2) v2(53.5,14) v2(53.7,6.4) v2(53.7,4.8) v2(54.85,22.15) v2(54.9,5.4) v2(55.1,14.2) v2(55.1,13) v2(55.1,0.8) v2(55.5,74.2) v2(55.9,4.8) v2(57.15,22.15) v2(57.2,24.25) v2(57.2,23.2) v2(57.3,4.25) v2(57.4,10.75) v2(59.3,74.2) v2(59.3,72.6) v2(59.3,70.8) v2(59.3,69) v2(59.5,14.8) v2(59.5,13.6) v2(59.6,23.2) v2(59.7,26.4) v2(59.7,4.25) v2(59.9,27.2) v2(59.9,22.15) v2(59.9,12.8) v2(60.3,7.6) v2(60.9,0.8) v2(61.4,64.3) v2(61.5,4.25) v2(63.1,74.2) v2(63.1,12.8) v2(63.5,15) v2(63.5,14) v2(63.5,4.25) v2(63.7,64.3) v2(63.9,0.8) v2(64.1,18.2) v2(64.1,16.6) v2(64.7,6) v2(64.7,5) v2(64.9,11.2) v2(64.9,9.2) v2(65.1,16.6) v2(65.1,15) v2(65.1,14) v2(65.75,62.75) v2(66.3,15.8) v2(66.5,74.2) v2(66.9,18.4) v2(67.1,11.4) v2(67.1,0.8) v2(67.7,3.2) v2(68.7,17.6) v2(68.7,5.6) v2(68.7,5) v2(68.7,4.4) v2(68.7,3.8) v2(68.7,3.2) v2(69.5,3) v2(69.7,6.2) v2(70.1,74.2) v2(70.9,8.8) v2(71.9,15) v2(72.9,71.8) v2(73.05,67.7) v2(73.5,11) v2(73.8,65.1) v2(76.5,15.4) v2(76.9,14.9) v2(78.45,14.9) v2(79.1,22) v2(79.1,18.4) v2(79.3,11) v2(80.05,10.7) v2(80.3,71.8) v2(80.6,46.75) v2(80.65,39.95) v2(80.7,10.25) v2(81.3,37.85) v2(81.3,9.85) v2(81.8,50.1) v2(81.8,9.4) v2(82.15,8.9) v2(82.5,8.2) v2(82.75,8.7) v2(82.95,7.55) v2(83.1,71.8) v2(83.1,69.8) v2(83.1,68.4) v2(83.1,15.8) v2(83.1,8.2) v2(83.5,7.8) v2(83.5,7.2) v2(83.5,6.6) v2(83.5,6) v2(83.5,5.4) v2(83.5,4.8) v2(83.5,4.2) v2(83.5,3.6) v2(83.5,3) v2(83.5,2.4) v2(83.5,1.8) v2(83.9,49.9) v2(83.9,1.4) v2(83.9,0.8) v2(84.1,6.6) v2(84.1,6) v2(84.1,5.4) v2(84.5,1.4) v2(84.5,0.8) v2(84.75,22.75) v2(84.75,21.9) v2(84.7,6.6) v2(84.7,6) v2(84.7,5.4) v2(85.3,68.4) v2(86.25,45.2) v2(86.7,51) v2(86.7,44.85) v2(86.9,55) v2(86.9,54) v2(87.1,56.2) v2(87.55,51) v2(87.5,46.9) v2(88.1,68.4) v2(88.5,55.2) v2(89.75,46.95) v2(89.75,44.85) v2(89.75,43.7) v2(89.75,41) v2(89.75,39.1) v2(90.3,37.85) v2(90.3,32.3) v2(90.3,29) v2(90.25,21.25) v2(90.7,68.4) v2(90.85,40.4) v2(90.85,39.1) v2(90.9,49.2) v2(91.3,26.4) v2(91.7,31.2) v2(91.65,20) v2(91.85,24.25) v2(91.9,74.2) v2(91.9,71.4) v2(91.9,69) v2(92.3,29) v2(92.3,26.4) v2(92.7,67) v2(92.7,24.25) v2(92.9,12) v2(93.3,29) v2(94.3,20.4) v2(94.4,18.35) v2(94.88,55.5) v2(94.9,54.75) v2(94.9,53.3) v2(94.88,52.6) v2(94.88,33.56) v2(94.88,32.81) v2(94.88,31.36) v2(94.88,30.66) v2(95.1,18.35) v2(95.7,63.8) v2(95.7,44.2) v2(95.7,41) v2(95.93,55.5) v2(95.93,54.75) v2(95.93,53.3) v2(95.93,52.6) v2(95.88,33.56) v2(95.88,32.81) v2(95.88,31.36) v2(95.88,30.66) v2(96.2,23.25) v2(96.75,19.6) v2(96.7,18.4) v2(96.93,55.5) v2(96.93,54.75) v2(96.93,53.3) v2(96.93,52.6) v2(96.93,33.56) v2(96.93,32.81) v2(96.93,31.36) v2(96.93,30.66) v2(97.35,0.75) v2(97.93,55.5) v2(97.93,54.75) v2(97.93,54.05) v2(97.93,53.3) v2(97.93,52.6) v2(97.93,33.56) v2(97.93,32.81) v2(97.93,32.11) v2(97.93,31.36) v2(97.93,30.66) v2(98.1,18.4) v2(98.15,19.6) v2(98.5,63) v2(98.98,55.51) v2(99,54.85) v2(98.98,54.06) v2(98.95,53.3) v2(98.98,52.61) v2(98.98,33.56) v2(98.98,32.81) v2(98.98,32.11) v2(98.98,31.36) v2(98.98,30.66) v2(99.35,19.6) v2(99.3,18.4) v2(99.7,43.8) v2(99.7,42.4) v2(99.7,0.75) v2(99.9,57.2) v2(100.3,63) v2(100.3,18.4) v2(100.5,43.8) v2(100.5,42.4) v2(100.7,57.2) v2(100.9,17.8) v2(101.3,44.6) v2(101.3,43.8) v2(101.3,42.4) v2(101.3,41.6) v2(101.3,22.4) v2(101.3,21.8) v2(101.3,21) v2(101.3,16.6) v2(101.3,15.2) v2(101.3,13.6) v2(101.9,44.6) v2(102,3.65) v2(102.1,63.6) v2(102.1,43.8) v2(102.1,42.4) v2(102.1,41.6) v2(102.1,22.4) v2(102.1,21.8) v2(102.1,21) v2(102.1,12.8) v2(102.8,43.1) v2(102.9,11.8) v2(102.9,10.2) v2(102.9,8.8) v2(103,3.65) v2(103.1,21) v2(103.3,0.75) v2(103.9,65) v2(104.1,21) v2(104.3,8.6) v2(105.5,67.4) v2(105.7,19.6) v2(105.7,17.2) v2(105.7,14.2) v2(105.7,11) v2(105.7,8) v2(105.9,21) v2(106.1,73.8) v2(106.1,69.8) v2(106.7,65.2) v2(107,43.1) v2(108.7,74.2) v2(110.1,65.2) v2(111.7,74.2) v2(113.3,65.2) v2(113.3,63.6) v2(114.9,74.2) v2(115.3,63.6) v2(115.3,58.6) v2(115.3,48.6) v2(116.3,55.4) v2(118.1,55.4) v2(118.5,74.2) v2(118.9,63.6) v2(118.9,58.6) v2(118.9,48.6) v2(118.9,37.6) v2(119.3,55.4) v2(119.3,54) v2(119.3,52.2) v2(119.9,26.4) v2(119.9,23.4) v2(120.9,35.6) v2(121.1,21.8) v2(121.3,74.2) v2(122.7,72.4) v2(122.7,69.8) v2(122.7,67) v2(122.7,63.6) v2(122.7,58.6) v2(122.7,53.6) v2(122.7,48.6) v2(122.7,43.6) v2(122.7,38.6) v2(122.7,33.6) v2(122.7,28.6) v2(122.7,23.6) v3(59.74,34.25) v3(59.71,31.66) v3(59.66,28.4)
