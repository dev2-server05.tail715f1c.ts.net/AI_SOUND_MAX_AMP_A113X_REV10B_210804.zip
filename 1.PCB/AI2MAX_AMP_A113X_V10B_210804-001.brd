# Allegro board AI2MAX_AMP_A113X_V10B_210804-001.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
N21715900 on TOP: 101.25,35.75 104.1,35.75 104.25,35.9 104.25,40.9 104.1,41.05 101.25,41.05 101.1,40.9 101.1,35.9
N21722582 on TOP: 25.95,34.7 28.8,34.7 28.95,34.85 28.95,39.85 28.8,40 25.95,40 25.8,39.85 25.8,34.85
N21723040 on TOP: 28.95,27.5 28.95,22.3 28.8,22.15 25.95,22.15 25.8,22.3 25.8,27.5
N21723435 on BOTTOM: 11.7,23.8 13,23.8 15.7,26.5 15.7,37.8 16,38.1 17.7,38.1 17.7,25.8 13.8,21.9 11.7,21.9 11.3,22.3 11.3,23.4
N21723437 on BOTTOM: 19.7,23.2 15.7,23.2 13.6,21.1 11.7,21.1 10.8,22 10.8,23.8 11.4,24.4 12.9,24.4 13.2,24.7 13.2,26.1 12.9,26.4 10.8,26.4 8.7,24.3 8.7,20.8 10.9,18.6 14.2,18.6 16.6,21 19.3,21 19.7,21.4
N21723451 on BOTTOM: 12.9,29.8 12.9,38 12.7,38.2 11.1,38.2 10.9,38 10.9,29.9 11.4,29.4 12.5,29.4
N21723475 on BOTTOM: 13.5,38.2 15,38.2 15.3,37.9 15.3,28.2 13.9,26.8 11.5,26.8 11.2,27.1 11.2,28.4 11.6,28.8 13,28.8 13.3,29.1 13.3,38
N21723494 on TOP: 25.95,56.65 28.8,56.65 28.95,56.8 28.95,61.8 28.8,61.95 25.95,61.95 25.8,61.8 25.8,56.8
N21724007 on TOP: 25.95,44.1 28.8,44.1 28.95,44.25 28.95,49.3 28.8,49.45 25.95,49.45 25.8,49.3 25.8,44.25
N21727322 on TOP: 94.2,7.2 94.2,15.4 96.65,17.85 99.9,17.85 100.7,17.05 100.7,15.8 99.95,15.05 98.45,15.05 97.3,13.9 97.3,11 97.8,10.5 97.8,7.2
N21727332 on TOP: 94.2,5.1 94.2,1.9 99.45,1.9 102.3,4.75 102.3,11.65 100,13.95 98.65,13.95 97.9,13.2 97.9,11.4 98.5,10.8 98.5,6.2 97.4,5.1
N22093750 on BOTTOM (solid shape): 108.3,45.85 107.8,45.35 106.3,45.35 106.3,47.85 108.3,47.85
N22093974 on BOTTOM: 114.9,54.2 116.9,54.2 116.9,51.7 115.3,51.7 114.9,52.1
N22094186 on BOTTOM: 106.3,26 106.3,23.6 108,23.6 108.3,23.9 108.3,26
N22099090 on BOTTOM: 21.7,37.2 23.8,37.2 23.8,39.7 22.1,39.7 21.7,39.3
N22099146 on BOTTOM: 21.7,25.2 23.5,25.2 23.5,22.9 22,22.9 21.7,23.2
N22099525 on BOTTOM: 16.4,58 13.9,58 13.7,57.8 13.7,56.3 13.9,56.1 16.4,56.1
N22099581 on BOTTOM (solid shape): 18,44.3 17,44.3 16.8,44.5 16.8,48 17,48.2 18,48.2

Small or netless copper shapes (teardrops, artwork): 1 on BOTTOM, 1 on MID1(L2), 1 on MID2(L3)

## Text on the board
BOTTOM: BOTTOM
Board Geometry/Soldermask Bottom: BOTTOM_SOLDERMASK
Ref Des/Silkscreen Bottom: NC | TD1 | TEN | TD0 | RD0 | RD1 | RCK | RDV | MIO | MDC | GND | VDD | VCC 3.3V | SPI_CLK | SPI_MOSI | SPI_MISO | SPI_SS | BL_EN | BL_PWM | LINE_OUT | RESET | I2C_SCK | I2C_SDA | AMP_RES | VDD 3.3V | AMP_DATA | AMP_BCLK | AMP_WCK | AMP_SCL | AMP_SDA | BOTTOM_SILKSCREEN
User.Comments: CR_UNNAMED_2 | 12.PCB Outline Dimension Tol: | 10.MATERIAL : | 11.PLATING : | 1. PCB VENDOR MUST BE UL  QUALIFIED | 2. BOARD MUST BE IDENTIFIED WITH APPROPRIATE VENDOR UL IDENTIFACTION MARK,DATE CODE | 3. PCB MATERIAL UL FLAMMIBILITY RATING(94V-0 MINIMUM) | 4. ALL DIMESION TOLERANCE AS BELOW UNLESS OTHERWISE SPECIFIED. | 5. PCB LAYERS : | 6. PCB THICKNESS : | 7. | 8. TOP SIDE SILKSCREEN : | 9. SOLDER MASK : | NOTES: | TRACE WIDTHS TO BE FINISHED SIZES+/-1MIL | BOTTOM SIDE SILKSCREEN: | 0.7mil(min) | Prepreg | Copper | Core | OSP 0.2-0.6um[8-24uinch]) | Top(L1) | Mid2(L3) | Bot(L4) | Mid1(L2) | FR4 | 4 LAYERs | GREEN | 1.6 mm+/-0.15 mm | TG: | ,BOTH SIDES | WHITE | 150 | 0.038 mm (H/1oz Finished) | 0.08 mm | 0.03 mm (1oz) | 1.274 mm | 0.015 mm | ROUTING : | CELSIUS | +/- 0.13mm | 1.6+/-0.15mm
TOP: TOP
Board Geometry/Soldermask Top: TOP_SOLDERMASK
Ref Des/Silkscreen Top: Label | 1 | 4 | AI2MAX AMP A113X REV1.0B | TOP_SILKSCREEN
MID1(L2): MID1(L2)
MID2(L3): MID2(L3)
PAGE_OUTLINE: Scale 1000mil | Layer name | PCB P/N | Rev. | Foxconn/CNSBG | 308.03524 | 015
DIMENSION: Prepreg | Copper | Core | Top(L1) | Mid2(L3) | Bot(L4) | Mid1(L2) | 0.038 mm (H/1oz Finished) | 0.08 mm | 0.03 mm (1oz) | 1.274 mm | 0.015 mm | 1.6+/-0.15mm | F
PLACE_BOUND_BOTTOM: 1 | Bottom Side Reflow | 0 degree | Top Side Reflow | 180 degree | Cavity_Number | *Reference CNSBG Break-Away rule | Unit:MM
User.15: MID3(L4)
User.16: MID4(L5)
User.17: MID5(L6)
User.18: MID6(L7)
User.19: MID7(L8)
User.20: MID8(L9)
User.21: MID9(L10)
User.22: MID11(L12)
User.23: MID12(L13)
User.26: BOTTOM_PASTE
User.27: TOP_PASTE
User.30: NCDRILL
User.32: BOTTOM_ASSEMBLY
User.33: TOP_ASSEMBLY
User.34: BOTTOM_ASSEMBLY
User.43: FIGURE | SIZE | 0.2 | 0.25 | 0.254 | 0.4064 | 1.0 | 1.1 | 1.8001 | 4.2 | 0.5 | 0.6 | 2.5 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILLIMETERS | TOLERANCE | +0.0762/-0.0762 | +0.0/-0.0 | PLATED | NON-PLATED | QTY | 429 | 1270 | 9 | 2 | 8 | 4 | 60 | 24
